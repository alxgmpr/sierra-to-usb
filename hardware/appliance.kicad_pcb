# Repository alxgmpr/sierra-to-usb (continued)

## KiCad design hardware/appliance.kicad_pcb (continued)

Schematic: peripheral-power.kicad_sch, Processor peripheral supplies and remote feedback

Parts:
C1401, C1403, C1404, C1406, C1407, C1409, C1410, C1412: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; MPN CL10B105KA8NNNC
C1402, C1405, C1408, C1411, C1420, C1421, C1422, C1423, C1424, C1425, C1426, C1427, C1428, C1429, C1430, C1431, C1432, C1433, C1434: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; MPN CL10B104KA8NNNC
C1441, C1442, C1443, C1444: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MPN CL10B105KA8NNNC
FB1401, FB1402, FB1403, FB1404: 120R @ 100MHz; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Current Rating 2A; MPN MPZ1608S121ATAH0
R1401, R1402, R1403: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07100RL
R1411, R1412, R1413, R1414: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603JR-070RL

Connections:
3V3_MAIN: C1434.1; also elsewhere on the board
CPU_FB: C1441.2, R1401.2, R1411.2; also elsewhere on the board
GND: C1401.2, C1402.2, C1403.2, C1404.2, C1405.2, C1406.2, C1407.2, C1408.2, C1409.2, C1410.2, C1411.2, C1412.2, C1420.2, C1421.2, C1422.2, C1423.2, C1424.2, C1425.2, C1426.2, C1427.2, C1428.2, C1429.2, C1430.2, C1431.2, C1432.2, C1433.2, C1434.2; also elsewhere on the board
GPU_FB: C1443.2, R1403.2, R1413.2; also elsewhere on the board
LOGIC_FB: C1442.2, R1402.2, R1412.2; also elsewhere on the board
MULTI_AVDD_0V9: C1401.1, C1402.1, C1403.1, FB1401.2; also elsewhere on the board
MULTI_AVDD_1V8: C1404.1, C1405.1, C1406.1, FB1402.2; also elsewhere on the board
NPU_FB: C1444.2, R1414.2; also elsewhere on the board
USB2_AVDD_0V9: C1407.1, C1408.1, C1409.1, FB1403.2; also elsewhere on the board
USB2_AVDD_1V8: C1410.1, C1411.1, C1412.1, FB1404.2; also elsewhere on the board
VCCA_1V8: C1421.1, C1423.1, C1425.1, C1427.1, C1429.1, C1431.1, C1433.1, FB1402.1, FB1404.1; also elsewhere on the board
VDDA_0V9: C1420.1, C1422.1, C1424.1, C1426.1, C1428.1, C1430.1, C1432.1, FB1401.1, FB1403.1; also elsewhere on the board
VDD_CPU: C1441.1, R1401.1, R1411.1; also elsewhere on the board
VDD_GPU: C1443.1, R1403.1, R1413.1; also elsewhere on the board
VDD_LOGIC: C1442.1, R1402.1, R1412.1; also elsewhere on the board
VDD_NPU: C1444.1, R1414.1; also elsewhere on the board

Notes on the sheet:
Local bypass at powered inactive MIPI/HDMI/eDP analog domains. Firmware keeps unused PHYs off; check combined RK809 LDO loading.
MULTI-PHY supplies serve PCIe plus USB3 OTG1. USB2 filters serve unused host PHY; keep host2/3 disabled. DCR drop, PDN impedance and reference tolerances require review.
100R || 1uF at DC/DC: feedback remains controlled if Kelvin trace opens. R1411–R1414 connect FB nets to power at processor load pads. NPU uses existing R512 (100R). Route FB separately to load.

Schematic: nic-interface.kicad_sch, PCIe and powered-off-safe Ethernet interfaces

Parts:
C1601, C1602, C1603, C1604: 100nF; C_0201_0603Metric_Pad0.64x0.40mm_HandSolder; Voltage Rating 6.3V; Tolerance 10%; MPN GRM033R60J104KE19D
C1605, C1606, C1607, C1608: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; MPN CL10B104KA8NNNC
Q1601: MMBT3904,215; SOT-23_Handsoldering; MPN MMBT3904,215
R1602, R1603: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-074K7L
R1604, R1606: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0710KL
R1605: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07100KL
U1601, U1602, U1603: SN74LVC1G07DCKR; SOT-353_SC-70-5; MPN SN74LVC1G07DCKR; LCSC C7830
U1604: TMUXHS4212IRKSR; DHVQFN-20-1EP_2.5x4.5mm_P0.5mm_EP1x3mm; MPN TMUXHS4212IRKSR; LCSC C3656912

Connections:
ETH_3V3: C1605.1, U1601.5 (VCC); also elsewhere on the board
ETH_3V3_GOOD: R1604.1; also elsewhere on the board
ETH_CLKREQ_N: U1602.2 (A); also elsewhere on the board
ETH_CLOCK_BASE: Q1601.1 (B), R1604.2, R1605.1
ETH_CLOCK_OE_N: Q1601.3 (C), R1606.2, U1604.2 (OEn)
ETH_PCIE_RXN: C1602.2; also elsewhere on the board
ETH_PCIE_RXP: C1601.2; also elsewhere on the board
ETH_PCIE_TXN: C1604.1; also elsewhere on the board
ETH_PCIE_TXP: C1603.1; also elsewhere on the board
ETH_PERST_N: U1601.4 (Y); also elsewhere on the board
ETH_REFCLK_N: U1604.18 (B0N); also elsewhere on the board
ETH_REFCLK_P: U1604.19 (B0P); also elsewhere on the board
ETH_WAKE_N: U1603.2 (A); also elsewhere on the board
GND: C1605.2, C1606.2, C1607.2, C1608.2, Q1601.2 (E), R1605.2, U1601.3 (GND), U1602.3 (GND), U1603.3 (GND), U1604.5 (GND), U1604.9 (SEL), U1604.11 (GND), U1604.20 (GND), U1604.21 (EP); also elsewhere on the board
PCIE_CLKREQ_N: R1602.2, U1602.4 (Y); also elsewhere on the board
PCIE_PERST_SOC_N: U1601.2 (A); also elsewhere on the board
PCIE_REFCLK_N: U1604.4 (A0n); also elsewhere on the board
PCIE_REFCLK_P: U1604.3 (A0p); also elsewhere on the board
PCIE_RXN_SOC: C1604.2; also elsewhere on the board
PCIE_RXP_SOC: C1603.2; also elsewhere on the board
PCIE_TXN_SOC: C1602.1; also elsewhere on the board
PCIE_TXP_SOC: C1601.1; also elsewhere on the board
PCIE_WAKE_N: R1603.2, U1603.4 (Y); also elsewhere on the board
VCC3V3_PMU: C1606.1, C1607.1, C1608.1, R1602.1, R1603.1, R1606.1, U1602.5 (VCC), U1603.5 (VCC), U1604.1 (RSVD1), U1604.6 (VCC), U1604.10 (RSVD2); also elsewhere on the board

Notes on the sheet:
100-ohm differential pairs; one AC-coupling capacitor per conductor at transmitter. SoC TX reaches NIC HSIP/HSIN; NIC HSOP/HSON reaches SoC RX. Keep PCIe controller quiescent before Ethernet power removal.
Clock disconnected by default. Valid switched 3.3V after U1504 delay turns Q1601 on. Mux stays on the SoC supply; NIC power cycling cannot turn on its clock path. Core reset delay ensures >100us clock-before-PERST margin. Validate shutdown transients.
RESET sinks: SoC U1601, supervisor Q303, core monitor U1505. No push-pull outputs share ETH_PERST_N. CLKREQ and wake outputs use Ioff buffers. While NIC is off, firmware ignores asserted wake/CLKREQ and disables ASPM.

Schematic: main5v.kicad_sch

Parts:
C701, C705: 100nF / 25V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MPN CL10B104KA8NNNC; LCSC C1590
C702: 47nF / 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Tolerance 10%; MPN CL10B473KB8NNNC; LCSC C1622
C703, C704: 10uF / 50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; MPN CL31B106KBHNNNE; LCSC C89632
C706, C707: 22uF / 25V; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; MPN CL32B226KAJNNNE; LCSC C309062
L701: 3.3uH; L_Coilcraft_XAL7070-XXX; MPN XAL7070-332MEC; LCSC C3911435
R701: 30.1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; MPN RC0603FR-0730K1L; LCSC C137745
R702: 73.2kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 0.1%; MPN RT0603BRD0773K2L; LCSC C861548
R703: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 0.1%; MPN RT0603BRD0710KL; LCSC C95204
R704: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; MPN RC0603FR-071KL; LCSC C22548
R705, R706: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; MPN RC0603FR-0710KL; LCSC C98220
U701: TPS56837RPAR; Texas_RPA0010A_TPS56837; MPN TPS56837RPAR; LCSC C22428366

Connections:
5V_MAIN: C706.1, C707.1, L701.2, R702.1; also elsewhere on the board
+3V3: R706.1; also elsewhere on the board
/Main 5V control/MAIN5V_FB: R702.2, R703.1, U701.2 (FB)
/Main 5V control/MAIN5V_MODE: R701.1, U701.10 (MODE)
/Main 5V control/MAIN5V_SW: C701.2, L701.1, U701.6 (SW)
GND: C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, R701.2, R703.2, R705.2, U701.3 (AGND), U701.9 (PGND); also elsewhere on the board
ISO_12V: C703.1, C704.1, C705.1, U701.8 (VIN); also elsewhere on the board
MAIN5V_GOOD: R706.2, U701.4 (PG); also elsewhere on the board
MCU_MAIN5V_EN: R704.1; also elsewhere on the board
unnamed: C701.1, U701.7 (BOOT)
unnamed: R704.2, R705.1, U701.1 (EN)
unnamed: C702.1, U701.5 (SS)

Notes on the sheet:
MAIN 5 V CONTROL — ENGINEERING CAPTURE
Power path captured. Regulator footprint, stability and thermal release remain pending.
MODE: 500 kHz; high valley current limit option. Feedback: 4.992 V nominal.
DRAFT: hot current margin, startup, input/output capacitance and loop stability unqualified.

Schematic: modem-power.kicad_sch, Independent modem power — 3.7V / burst allocation 5A

Parts:
C1901, C1907, C1909, C1912, C1913, C1914: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; MPN CL10B104KA8NNNC
C1902, C1903, C1904: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; Voltage Rating 25V; MPN CL32B226KAJNNNE
C1905, C1906: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage Rating 25V; MPN CL31B106KAHNNNE
C1908: 47nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; MPN CL10B473KB8NNNC
C1910: 1nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; MPN CL10B102KB8NNNC
C1911: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; MPN CL10B103KB8NNNC
L1901: 3.3uH; L_Coilcraft_XAL7070-XXX; MPN XAL7070-332MEC
Q1901: AO3400A; SOT-23_Handsoldering; MPN AO3400A; LCSC C20917
R1901: 36.3kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 0.1%; Power Rating 0.1W; MPN RT0603BRD0736K3L
R1902: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 0.1%; Power Rating 0.1W; MPN RT0603BRD0710KL
R1903, R1905, R1912, R1914, R1916, R1925, R1926: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07100KL
R1904, R1906, R1911, R1918, R1923: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0710KL
R1907: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-071KL
R1913: 237kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07237KL
R1915: 165kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07165KL
R1917: 562R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 0.1%; Power Rating 0.1W; MPN RT0603BRD07562RL
R1921: 330kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 0.1%; Power Rating 0.1W; MPN RT0603BRD07330KL
R1922: 47kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 0.1%; Power Rating 0.1W; MPN RT0603BRD0747KL
R1924: 100R / 0.25W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; Power Rating 0.25W; Tolerance 1%; MPN RC1206FR-07100RL
U1901: TPS54620RHLR; VQFN-14_L3.5-W3.5-P0.50-TL-EP_TPS54622RHLT; MPN TPS54620RHLR; LCSC C263274
U1902: TPS259474LRPWR; VQFN-10_L2.0-W2.0-P0.45-TL; MPN TPS259474LRPWR; LCSC C2864845
U1903: TPS3808G01DBVR; SOT-23-6_Handsoldering; MPN TPS3808G01DBVR; LCSC C19653
U1904: SN74LVC1G04DCKR; SOT-353_SC-70-5; MPN SN74LVC1G04DCKR

Connections:
+3V3: C1913.1, C1914.1, R1906.1, R1918.1, R1923.1, R1926.1, U1903.3 (MR), U1903.6 (VDD), U1904.5 (VCC); also elsewhere on the board
GND: C1902.2, C1903.2, C1904.2, C1905.2, C1906.2, C1907.2, C1908.2, C1909.2, C1910.2, C1911.2, C1912.2, C1913.2, C1914.2, Q1901.2 (S), R1902.2, R1903.2, R1905.2, R1912.2, R1914.2, R1916.2, R1917.2, R1922.2, R1925.2, U1901.2 (GND), U1901.3 (GND), U1901.15 (EP), U1902.8 (GND), U1903.2 (GND), U1904.3 (GND); also elsewhere on the board
ISO_12V: C1905.1, C1906.1, C1907.1, U1901.4 (PVIN), U1901.5 (PVIN), U1901.6 (VIN); also elsewhere on the board
MCU_MODEM_POWER_EN: R1904.1, R1911.1, R1925.1, U1904.2; also elsewhere on the board
MODEM_3V7_RAW: C1902.1, C1903.1, C1904.1, C1912.1, L1901.2, R1901.1, R1913.1, U1902.5 (IN)
MODEM_BUCK_BOOT: C1901.1, U1901.13 (BOOT)
MODEM_BUCK_COMP: C1910.1, R1907.1, U1901.8 (COMP)
MODEM_BUCK_EN: R1904.2, R1905.1, U1901.10 (EN)
MODEM_BUCK_FB: R1901.2, R1902.1, U1901.7 (VSENSE)
MODEM_BUCK_GOOD: R1906.2, U1901.14 (PWRGD); also elsewhere on the board
MODEM_BUCK_RT: R1903.1, U1901.1 (RT/CLK)
MODEM_BUCK_SS: C1908.1, U1901.9 (SS/TR)
MODEM_BUCK_SW: C1901.2, L1901.1, U1901.11 (PH), U1901.12 (PH)
MODEM_COMP_RC: C1909.1, R1907.2
MODEM_DISCHARGE_DRAIN: Q1901.3 (D), R1924.2
MODEM_DISCHARGE_GATE: Q1901.1 (G), U1904.4
MODEM_FUSE_DVDT: C1911.1, U1902.7 (DVDT)
MODEM_FUSE_EN: R1911.2, R1912.1, U1902.1 (EN/UVLO)
MODEM_FUSE_ILM: R1917.1, U1902.9 (ILM)
MODEM_FUSE_OVLO: R1913.2, R1914.1, U1902.2 (OVLO/OVCSEL)
MODEM_FUSE_PGTH: R1915.2, R1916.1, U1902.4 (PGTH/~FLT)
MODEM_MON_CT: R1926.2, U1903.4 (CT)
MODEM_MON_SENSE: R1921.2, R1922.1, U1903.5 (SENSE)
MODEM_RAIL_GOOD: R1923.2, U1903.1 (RESET); also elsewhere on the board
MODEM_SWITCH_GOOD: R1918.2, U1902.3 (PG/AUXOFF); also elsewhere on the board
MODEM_VCC: R1915.1, R1921.1, R1924.1, U1902.6 (OUT); also elsewhere on the board

Notes on the sheet:
U1903 is powered from always-on 3.3V; output threshold nominal 3.249V. CT via 100k to VDD: 180–420ms delay exceeds Sierra 100ms no-drive interval. MODEM_RAIL_GOOD drives data isolation and MCU PB13 (pad25). MCU PA0 controls power. Low command enables Q1901 discharge; wait at least 1s and bench-veri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
Compensated current-mode regulator supports the downstream 220uF modem bulk bank. Type II: 1k / 100nF, 1nF high-frequency pole. Include eFuse resistance and both banks in loop analysis. Verify loop, burst droop, soft-start and thermal behavior on hardware. 5A is a provisional burst design allocatio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
Latch-off eFuse: 45mOhm maximum RON. 562R/0.1% gives approx. 5.27–6.45A threshold using the 549R guaranteed table, NOT 5A continuous connector qualification. ITIMER open. OVLO: 237k/100k, 3.93–4.18V resistor/reference corners, below modem 4.4V limit. PGTH: 165k/100k, nominal 3.18V. Use separate alw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

Schematic: modem-bypass.kicad_sch, Modem local bulk and RF bypass

Parts:
C2030: 220uF / 6.3V; CP_Elec_6.3x5.9; Tolerance 20%; MPN 6SVPC220MV
C2031, C2032, C2033, C2034, C2035: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; MPN CL10B104KA8NNNC
C2036, C2037, C2038: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; MPN CL10B104KA8NNNC; not fitted
C2041: 220pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; MPN CL10C221JB8NNNC
C2042: 68pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; MPN CL10C680JB8NNNC
C2043: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; MPN CL10C150JB8NNNC
C2044: 9.1pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; MPN CL10C9R1BB8NNNC
C2045: 4.7pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; MPN CL10C4R7BB8NNNC

Connections:
GND: C2030.2, C2031.2, C2032.2, C2033.2, C2034.2, C2035.2, C2036.2, C2037.2, C2038.2, C2041.2, C2042.2, C2043.2, C2044.2, C2045.2; also elsewhere on the board
M2_PIN24: C2036.1; also elsewhere on the board
M2_PIN38: C2037.1; also elsewhere on the board
M2_PIN68: C2038.1; also elsewhere on the board
MODEM_VCC: C2030.1, C2031.1, C2032.1, C2033.1, C2034.1, C2035.1, C2041.1, C2042.1, C2043.1, C2044.1, C2045.1; also elsewhere on the board

Notes on the sheet:
C2030 and RF bank at socket. One 100nF at each of five common VCC contacts. C2036/37/38 SIERRA ONLY: DNP in Quectel profiles along with their feed links. Confirm effective MLCC capacitance at DC bias and full modem internal capacitance. Layout must share current across every populated VCC/GND conta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

Schematic: nic.kicad_sch, 2.5GbE controller — RTL8125BG external-core variant

Parts:
C1301: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; MPN CL10B104KA8NNNC
C1302, C1303: 27pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; Tolerance 5%; MPN CL10C270JB8NNNC
FB1301, FB1302: 120R @ 100MHz; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Current Rating 2A; MPN MPZ1608S121ATAH0
FB1303, FB1304: 30R @ 100MHz; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder; Current Rating 6A; MPN MPZ2012S300AT000
R1301, R1306: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0710KL
R1302: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-071KL
R1303, R1304, R1305: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-074K7L
R1307: 2.49kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-072K49L
U1301: RTL8125BG-CG; TQFN-48_L6.0-W6.0-P0.40-BL-EP4.5; MPN RTL8125BG-CG; LCSC C3013605
U1302: 93LC46BT-I/SN; SOIC-8_3.9x4.9mm_P1.27mm; MPN 93LC46BT-I/SN; LCSC C16253
Y1301: 25MHz, 18pF; Crystal_SMD_TXC_7M-4Pin_3.2x2.5mm_HandSoldering; Frequency Tolerance 10ppm; MPN 7M-25.000MEIJ-T

Connections:
ETH_0V95: FB1303.1, FB1304.1, U1301.8 (DVDD09), U1301.28 (DVDD09), U1301.47 (DVDD09); also elsewhere on the board
ETH_3V3: C1301.1, FB1301.1, FB1302.1, R1301.1, R1302.1, R1303.1, R1304.1, U1301.29 (DVDD33), U1301.43 (EVDD33), U1301.46 (DVDD33), U1302.8 (VCC); also elsewhere on the board
ETH_ANALOG_0V95: FB1303.2, U1301.11 (AVDD09), U1301.16 (AVDD09), U1301.22 (AVDD09); also elsewhere on the board
ETH_ANALOG_3V3: FB1301.2, U1301.15 (AVDD33), U1301.19 (AVDD33), U1301.33 (AVDD33); also elsewhere on the board
ETH_CLKREQ_N: R1303.2, U1301.48 (CLKREQB); also elsewhere on the board
ETH_CORE_EN: U1301.6 (POW_EXT_SWR); also elsewhere on the board
ETH_EE_CLK: R1304.2, U1301.27 (LED1/EESK/SPISC), U1302.2 (CLK)
ETH_EE_CS: U1301.31 (EECS/SCL), U1302.1 (CS)
ETH_EE_DI: R1305.1, U1301.30 (LED0/EEDI/SPISI/SDA), U1302.3 (DI)
ETH_EE_DO: U1301.25 (LED2/EEDO/SPIS0), U1302.4 (DO)
ETH_EE_SEL: R1306.1, U1301.32 (EEPROM_SEL/PPS_PIN)
ETH_ISOLATE_N: R1301.2, U1301.1 (ISOLATEB)
ETH_MDI0_N: U1301.14 (MDIN0); also elsewhere on the board
ETH_MDI0_P: U1301.13 (MDIP0); also elsewhere on the board
ETH_MDI1_N: U1301.18 (MDIN1); also elsewhere on the board
ETH_MDI1_P: U1301.17 (MDIP1); also elsewhere on the board
ETH_MDI2_N: U1301.21 (MDIN2); also elsewhere on the board
ETH_MDI2_P: U1301.20 (MDIP2); also elsewhere on the board
ETH_MDI3_N: U1301.24 (MDIN3); also elsewhere on the board
ETH_MDI3_P: U1301.23 (MDIP3); also elsewhere on the board
ETH_PCIE_0V95: FB1304.2, U1301.37 (EVDD09); also elsewhere on the board
ETH_PCIE_RXN: U1301.42 (HSIN); also elsewhere on the board
ETH_PCIE_RXP: U1301.41 (HSIP); also elsewhere on the board
ETH_PCIE_TXN: U1301.39 (HSON); also elsewhere on the board
ETH_PCIE_TXP: U1301.38 (HSOP); also elsewhere on the board
ETH_PERST_N: U1301.36 (PERSTB); also elsewhere on the board
ETH_REFCLK_N: U1301.45 (REFCLK_N); also elsewhere on the board
ETH_REFCLK_P: U1301.44 (REFCLK_P); also elsewhere on the board
ETH_RSET: R1307.1, U1301.12 (RSET)
ETH_WAKE_N: R1302.2, U1301.2 (LANWAKEB); also elsewhere on the board
ETH_XTAL_3V3: FB1302.2, U1301.34 (AVDD33_XTAL); also elsewhere on the board
ETH_XTAL_IN: C1302.1, U1301.10 (CKXTAL1), Y1301.1
ETH_XTAL_OUT: C1303.1, U1301.9 (CKXTAL2), Y1301.3
GND: C1301.2, C1302.2, C1303.2, R1305.2, R1306.2, R1307.2, U1301.40 (GND), U1301.49 (GND), U1302.5 (VSS), Y1301.2 (G), Y1301.4 (G); also elsewhere on the board

Notes on the sheet:
LANWAKE requires 1–4.7k pull-up. EESK requires 4.7k pull-up; low enters test mode. EEDI low selects Microwire, EEPROM_SEL low selects 93C46. All strap levels at power-on. BG pins 4/5/7 float; all 49 pads audited. 2.5G magnetics and four-pair PoE attached; qualify hardware.

Schematic: poe-pd.kicad_sch, Class-6 powered device — fixed assembly configuration

Parts:
C1716: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; Tolerance 10%; MPN GRM188R61H103KA01D
C1717: 47uF / 63V; TI_SM_RADIAL_F; Voltage Rating 63V; MPN EEE-FK1J470P
C1718: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; Tolerance 10%; MPN 06033D104KAT2A
C1719: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Voltage Rating 100V; Tolerance 10%; MPN C0805C104K1RACTU
R1723: 24.9kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN CRCW060324K9FKEA
R1724: 63.4R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN CRCW060363R4FKEA
R1727: 249R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN CRCW0603249RFKEA
R1730: 1kR; R_2010_5025Metric_Pad1.40x2.65mm_HandSolder; Tolerance 1%; Power Rating 0.75W; MPN CRCW20101K00FKEF
R1732: 49.9kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN CRCW060349K9FKEA
U1701: TPS2373-3RGWR; Texas_RGW0020A_VQFN-20-1EP_5x5mm_P0.65mm_EP3.15x3.15mm; MPN TPS2373-3RGWR

Connections:
POE_AMPS_CTL: R1730.1, U1701.8 (AMPS_CTL)
POE_BT: U1701.19 (BT); also elsewhere on the board
POE_CLSA: R1724.1, U1701.3 (CLSA)
POE_CLSB: R1727.1, U1701.6 (CLSB)
POE_DEN: R1723.2, U1701.2 (DEN)
POE_REF: R1732.1, U1701.7 (REF)
POE_RTN: C1716.2, C1717.2, C1718.2, U1701.10 (APD), U1701.11 (RTN), U1701.12 (RTN); also elsewhere on the board
POE_TPH: U1701.18 (TPH); also elsewhere on the board
POE_TPL: U1701.17 (TPL); also elsewhere on the board
POE_UVLO: U1701.13 (PG); also elsewhere on the board
POE_VCIN: C1716.1, U1701.15 (VC_IN); also elsewhere on the board
POE_VCOUT: C1718.1, U1701.14 (VC_OUT); also elsewhere on the board
POE_VDD: C1717.1, C1719.1, R1723.1, U1701.1 (VDD); also elsewhere on the board
POE_VSS: C1719.2, R1724.2, R1727.2, R1730.2, R1732.2, U1701.4 (VSS), U1701.5 (VSS), U1701.9 (MPS_DUTY), U1701.21 (PAD); also elsewhere on the board

Notes on the sheet:
Fixed Class 6: CLSA 63.4R, CLSB 249R. Accept only 51W bt grant: TPH low / TPL high / BT low. Three optocouplers carry status across isolation to the always-on supervisor. No auxiliary input. APD tied to RTN; detection resistor changes from reference 27.4k to 24.9k because its auxiliary-divider para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

Schematic: core-power.kicad_sch, Processor logic, GPU and DDR local bypass — DRAFT

Parts:
C825, C832, C837, C838, C839, C842, C843, C844: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; Tolerance 10%; MPN CL10B104KA8NNNC; LCSC C1590
C826, C827, C828, C833, C840, C845, C846: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; Tolerance 10%; MPN CL10A475KA8NQNC; LCSC C69335
C829, C831, C834, C836: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; Voltage Rating 25V; Tolerance 10%; MPN CL32B226KAJNNNE; LCSC C309062
C830, C835, C841: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage Rating 25V; Tolerance 10%; MPN CL31B106KAHNNNE; LCSC C14860

Connections:
GND: C825.2, C826.2, C827.2, C828.2, C829.2, C830.2, C831.2, C832.2, C833.2, C834.2, C835.2, C836.2, C837.2, C838.2, C839.2, C840.2, C841.2, C842.2, C843.2, C844.2, C845.2, C846.2; also elsewhere on the board
VDD_DDR_0V6: C842.1, C843.1, C844.1, C845.1, C846.1; also elsewhere on the board
VDD_DDR_1V1: C837.1, C838.1, C839.1, C840.1, C841.1; also elsewhere on the board
VDD_GPU: C832.1, C833.1, C834.1, C835.1, C836.1; also elsewhere on the board
VDD_LOGIC: C825.1, C826.1, C827.1, C828.1, C829.1, C830.1, C831.1; also elsewhere on the board

Notes on the sheet:
VDD_LOGIC: local bypass; first 4 capacitors under package, remaining capacitors nearby.
VDD_GPU: local bypass; first 2 capacitors under package, remaining capacitors nearby.
VDD_DDR_1V1: local bypass; first 5 capacitors under package, remaining capacitors nearby.
VDD_DDR_0V6: local bypass; first 5 capacitors under package, remaining capacitors nearby.
DRAFT CORE BYPASS: NanoPi R3S LTS 2411 sheets 5/6 nominal values. Effective capacitance, layout feasibility, PDN impedance and regulator stability remain to verify.

Schematic: ram.kicad_sch, Micron RAM — DRAFT: supplies and DDR bus incomplete

Parts:
C905, C909, C914, C915, C916, C934, C935, C936: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage Rating 25V; Tolerance 10%; MPN CL31B106KAHNNNE; LCSC C14860
C906, C907, C908, C910, C911, C912, C917, C918, C919, C920, C921, C922, C923, C924, C925, C926, C927, C928, C929, C930, C931, C932, C937, C938, C939, C940, C941, C942, C943, C944, C945, C946, C947, C948, C949, C950, C951, C952, C953, C954: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; Tolerance 10%; MPN CL10B104KA8NNNC; LCSC C1590
C913, C933: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; Voltage Rating 25V; Tolerance 10%; MPN CL32B226KAJNNNE; LCSC C309062
R903: 240R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07240RL; LCSC C114613
U901: MT53E512M32D1ZW-046 WT:B; Sierra_Micron_ZW_TFBGA200; MPN MT53E512M32D1ZW-046 WT:B; LCSC C5330500

Connections:
DDR_A_CLKN: U901.J9 (CK_c_A); also elsewhere on the board
DDR_A_CLKP: U901.J8 (CK_t_A); also elsewhere on the board
DDR_A_DQS0N: U901.E3 (DQS0_c_A); also elsewhere on the board
DDR_A_DQS0P: U901.D3 (DQS0_t_A); also elsewhere on the board
DDR_A_DQS1N: U901.E10 (DQS1_c_A); also elsewhere on the board
DDR_A_DQS1P: U901.D10 (DQS1_t_A); also elsewhere on the board
DDR_B_CLKN: U901.P9 (CK_c_B); also elsewhere on the board
DDR_B_CLKP: U901.P8 (CK_t_B); also elsewhere on the board
DDR_B_DQS0N: U901.V3 (DQS0_c_B); also elsewhere on the board
DDR_B_DQS0P: U901.W3 (DQS0_t_B); also elsewhere on the board
DDR_B_DQS1N: U901.V10 (DQS1_c_B); also elsewhere on the board
DDR_B_DQS1P: U901.W10 (DQS1_t_B); also elsewhere on the board
GND: C905.2, C906.2, C907.2, C908.2, C909.2, C910.2, C911.2, C912.2, C913.2, C914.2, C915.2, C916.2, C917.2, C918.2, C919.2, C920.2, C921.2, C922.2, C923.2, C924.2, C925.2, C926.2, C927.2, C928.2, C929.2, C930.2, C931.2, C932.2, C933.2, C934.2, C935.2, C936.2, C937.2, C938.2, C939.2, C940.2, C941.2, C942.2, C943.2, C944.2, C945.2, C946.2, C947.2, C948.2, C949.2, C950.2, C951.2, C952.2, C953.2, C954.2, U901.A3 (VSS), U901.A10 (VSS), U901.AB3 (VSS), U901.AB5 (VSS), U901.AB8 (VSS), U901.AB10 (VSS), U901.C1 (VSS), U901.C5 (VSS), U901.C8 (VSS), U901.C12 (VSS), U901.D2 (VSS), U901.D4 (VSS), U901.D9 (VSS), U901.D11 (VSS), U901.E1 (VSS), U901.E5 (VSS), U901.E8 (VSS), U901.E12 (VSS), U901.G1 (VSS), U901.G2 (ODT_CA_A), U901.G3 (VSS), U901.G5 (VSS), U901.G8 (VSS), U901.G10 (VSS), U901.G12 (VSS), U901.J1 (VSS), U901.J3 (VSS), U901.J10 (VSS), U901.J12 (VSS), U901.K2 (VSS), U901.K4 (VSS), U901.K9 (VSS), U901.K11 (VSS), U901.N2 (VSS), U901.N4 (VSS), U901.N9 (VSS), U901.N11 (VSS), U901.P1 (VSS), U901.P3 (VSS), U901.P10 (VSS), U901.P12 (VSS), U901.T1 (VSS), U901.T2 (ODT_CA_B), U901.T3 (VSS), U901.T5 (VSS), U901.T8 (VSS), U901.T10 (VSS), U901.T12 (VSS), U901.V1 (VSS), U901.V5 (VSS), U901.V8 (VSS), U901.V12 (VSS), U901.W2 (VSS), U901.W4 (VSS), U901.W9 (VSS), U901.W11 (VSS), U901.Y1 (VSS), U901.Y5 (VSS), U901.Y8 (VSS), U901.Y12 (VSS); also elsewhere on the board
LPDDR4_A0_A: U901.H2 (CA0_A); also elsewhere on the board
LPDDR4_A0_B: U901.R2 (CA0_B); also elsewhere on the board
LPDDR4_A1_A: U901.J2 (CA1_A); also elsewhere on the board
LPDDR4_A1_B: U901.P2 (CA1_B); also elsewhere on the board
LPDDR4_A2_A: U901.H9 (CA2_A); also elsewhere on the board
LPDDR4_A2_B: U901.R9 (CA2_B); also elsewhere on the board
LPDDR4_A3_A: U901.H10 (CA3_A); also elsewhere on the board
LPDDR4_A3_B: U901.R10 (CA3_B); also elsewhere on the board
LPDDR4_A4_A: U901.H11 (CA4_A); also elsewhere on the board
LPDDR4_A4_B: U901.R11 (CA4_B); also elsewhere on the board
LPDDR4_A5_A: U901.J11 (CA5_A); also elsewhere on the board
LPDDR4_A5_B: U901.P11 (CA5_B); also elsewhere on the board
LPDDR4_CKE0_A: U901.J4 (CKE0_A); also elsewhere on the board
LPDDR4_CKE0_B: U901.P4 (CKE0_B); also elsewhere on the board
LPDDR4_CS0n_A: U901.H4 (CS0_A); also elsewhere on the board
LPDDR4_CS0n_B: U901.R4 (CS0_B); also elsewhere on the board
LPDDR4_DM0_A: U901.C3 (DMI0_A); also elsewhere on the board
LPDDR4_DM0_B: U901.Y3 (DMI0_B); also elsewhere on the board
LPDDR4_DM1_A: U901.C10 (DMI1_A); also elsewhere on the board
LPDDR4_DM1_B: U901.Y10 (DMI1_B); also elsewhere on the board
LPDDR4_DQ0_A: U901.B2 (DQ0_A); also elsewhere on the board
LPDDR4_DQ0_B: U901.AA2 (DQ0_B); also elsewhere on the board
LPDDR4_DQ1_A: U901.C2 (DQ1_A); also elsewhere on the board
LPDDR4_DQ1_B: U901.Y2 (DQ1_B); also elsewhere on the board
LPDDR4_DQ2_A: U901.E2 (DQ2_A); also elsewhere on the board
LPDDR4_DQ2_B: U901.V2 (DQ2_B); also elsewhere on the board
LPDDR4_DQ3_A: U901.F2 (DQ3_A); also elsewhere on the board
LPDDR4_DQ3_B: U901.U2 (DQ3_B); also elsewhere on the board
LPDDR4_DQ4_A: U901.F4 (DQ4_A); also elsewhere on the board
LPDDR4_DQ4_B: U901.U4 (DQ4_B); also elsewhere on the board
LPDDR4_DQ5_A: U901.E4 (DQ5_A); also elsewhere on the board
LPDDR4_DQ5_B: U901.V4 (DQ5_B); also elsewhere on the board
LPDDR4_DQ6_A: U901.C4 (DQ6_A); also elsewhere on the board
LPDDR4_DQ6_B: U901.Y4 (DQ6_B); also elsewhere on the board
LPDDR4_DQ7_A: U901.B4 (DQ7_A); also elsewhere on the board
LPDDR4_DQ7_B: U901.AA4 (DQ7_B); also elsewhere on the board
LPDDR4_DQ8_A: U901.B11 (DQ8_A); also elsewhere on the board
LPDDR4_DQ8_B: U901.AA11 (DQ8_B); also elsewhere on the board
LPDDR4_DQ9_A: U901.C11 (DQ9_A); also elsewhere on the board
LPDDR4_DQ9_B: U901.Y11 (DQ9_B); also elsewhere on the board
LPDDR4_DQ10_A: U901.E11 (DQ10_A); also elsewhere on the board
LPDDR4_DQ10_B: U901.V11 (DQ10_B); also elsewhere on the board
LPDDR4_DQ11_A: U901.F11 (DQ11_A); also elsewhere on the board
LPDDR4_DQ11_B: U901.U11 (DQ11_B); also elsewhere on the board
LPDDR4_DQ12_A: U901.F9 (DQ12_A); also elsewhere on the board
LPDDR4_DQ12_B: U901.U9 (DQ12_B); also elsewhere on the board
LPDDR4_DQ13_A: U901.E9 (DQ13_A); also elsewhere on the board
LPDDR4_DQ13_B: U901.V9 (DQ13_B); also elsewhere on the board
LPDDR4_DQ14_A: U901.C9 (DQ14_A); also elsewhere on the board
LPDDR4_DQ14_B: U901.Y9 (DQ14_B); also elsewhere on the board
LPDDR4_DQ15_A: U901.B9 (DQ15_A); also elsewhere on the board
LPDDR4_DQ15_B: U901.AA9 (DQ15_B); also elsewhere on the board
LPDDR4_RESETn: U901.T11 (RESET_n); also elsewhere on the board
unnamed: R903.2, U901.A5 (ZQ0)
VCC_1V8: C905.1, C906.1, C907.1, C908.1, C909.1, C910.1, C911.1, C912.1, U901.F1 (VDD1), U901.F12 (VDD1), U901.G4 (VDD1), U901.G9 (VDD1), U901.T4 (VDD1), U901.T9 (VDD1), U901.U1 (VDD1), U901.U12 (VDD1); also elsewhere on the board
VDD_DDR_0V6: C933.1, C934.1, C935.1, C936.1, C937.1, C938.1, C939.1, C940.1, C941.1, C942.1, C943.1, C944.1, C945.1, C946.1, C947.1, C948.1, C949.1, C950.1, C951.1, C952.1, C953.1, C954.1, R903.1, U901.AA3 (VDDQ), U901.AA5 (VDDQ), U901.AA8 (VDDQ), U901.AA10 (VDDQ), U901.B3 (VDDQ), U901.B5 (VDDQ), U901.B8 (VDDQ), U901.B10 (VDDQ), U901.D1 (VDDQ), U901.D5 (VDDQ), U901.D8 (VDDQ), U901.D12 (VDDQ), U901.F3 (VDDQ), U901.F10 (VDDQ), U901.U3 (VDDQ), U901.U10 (VDDQ), U901.W1 (VDDQ), U901.W5 (VDDQ), U901.W8 (VDDQ), U901.W12 (VDDQ); also elsewhere on the board
VDD_DDR_1V1: C913.1, C914.1, C915.1, C916.1, C917.1, C918.1, C919.1, C920.1, C921.1, C922.1, C923.1, C924.1, C925.1, C926.1, C927.1, C928.1, C929.1, C930.1, C931.1, C932.1, U901.A4 (VDD2), U901.A9 (VDD2), U901.AB4 (VDD2), U901.AB9 (VDD2), U901.F5 (VDD2), U901.F8 (VDD2), U901.H1 (VDD2), U901.H5 (VDD2), U901.H8 (VDD2), U901.H12 (VDD2), U901.K1 (VDD2), U901.K3 (VDD2), U901.K10 (VDD2), U901.K12 (VDD2), U901.N1 (VDD2), U901.N3 (VDD2), U901.N10 (VDD2), U901.N12 (VDD2), U901.R1 (VDD2), U901.R5 (VDD2), U901.R8 (VDD2), U901.R12 (VDD2), U901.U5 (VDD2), U901.U8 (VDD2); also elsewhere on the board

Notes on the sheet:
VDD_DDR_1V1: RAM-local bypass; nominal reference values. Physical PDN qualification pending.
VCC_1V8: RAM-local bypass; nominal reference values. Physical PDN qualification pending.
VDD_DDR_0V6: RAM-local bypass; nominal reference values. Physical PDN qualification pending.

Schematic: nic-power.kicad_sch, Ethernet power and hardware reset sequencing

Parts:
C1501, C1504, C1508, C1509: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; MPN CL10B104KA8NNNC
C1502: 1nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 50V; MPN CL10B102KB8NNNC
C1503, C1505, C1507: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage Rating 25V; MPN CL31B106KAHNNNE
C1506: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; Voltage Rating 25V; MPN CL32B226KAJNNNE
L1501: 2.2uH; L_Coilcraft_XxL4020; MPN XGL4020-222MEC
R1501, R1502, R1503, R1507, R1508: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07100KL
R1504: 59kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 0.1%; Power Rating 0.1W; MPN RT0603BRD0759KL
R1505: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 0.1%; Power Rating 0.1W; MPN RT0603BRD07100KL
R1506: 115kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07115KL
R1509, R1510: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0710KL
U1501: SN74LVC1G125DCKR; SOT-353_SC-70-5; MPN SN74LVC1G125DCKR; LCSC C7833
U1502: TPS22965DSGR; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN TPS22965DSGR; LCSC C122837
U1503: SY8089AAAC; SOT-23-5_HandSoldering; MPN SY8089AAAC; LCSC C78988
U1504: TPS3808G33DBVR; SOT-23-6_Handsoldering; MPN TPS3808G33DBVR; LCSC C43698
U1505: TPS3808G01DBVR; SOT-23-6_Handsoldering; MPN TPS3808G01DBVR; LCSC C19653

Connections:
3V3_MAIN: C1501.1, U1501.5 (VCC), U1502.1 (VIN), U1502.2 (VIN); also elsewhere on the board
5V_MAIN: C1504.1, U1502.4 (VBIAS); also elsewhere on the board
ETH_0V95: C1506.1, C1507.1, L1501.2, R1504.1, R1506.1; also elsewhere on the board
ETH_3V3: C1503.1, C1505.1, C1508.1, C1509.1, R1508.1, R1509.1, R1510.1, U1502.7 (VOUT), U1502.8 (VOUT), U1503.4 (IN), U1504.3 (MR), U1504.5 (SENSE), U1504.6 (VDD), U1505.3 (MR), U1505.6 (VDD); also elsewhere on the board
ETH_3V3_GOOD: R1510.2, U1504.1 (RESET); also elsewhere on the board
ETH_CORE_EN: R1503.1, U1503.1 (EN); also elsewhere on the board
ETH_CORE_FB: R1504.2, R1505.1, U1503.5 (FB)
ETH_CORE_SENSE: R1506.2, R1507.1, U1505.5 (SENSE)
ETH_CORE_SW: L1501.1, U1503.3 (LX)
ETH_PERST_N: R1509.2, U1505.1 (RESET); also elsewhere on the board
ETH_RESET_CT: R1508.2, U1505.4 (CT)
ETH_SWITCH_CT: C1502.1, U1502.6 (CT)
ETH_SWITCH_EN: R1502.1, U1501.4, U1502.3 (ON)
GND: C1501.2, C1502.2, C1503.2, C1504.2, C1505.2, C1506.2, C1507.2, C1508.2, C1509.2, R1501.2, R1502.2, R1503.2, R1505.2, R1507.2, U1501.1, U1501.3 (GND), U1502.5 (GND), U1502.9 (EP), U1503.2 (GND), U1504.2 (GND), U1505.2 (GND); also elsewhere on the board
MCU_ETH_POWER_EN: R1501.1, U1501.2; also elsewhere on the board

Notes on the sheet:
Ioff buffer prevents MCU back-power when main supply is off. CT=1nF, VBIAS=5V: 1.33ms typical 3.3V rise (TI Table 1). Quick-output discharge 225R typical; measured decay required.
G33: open CT gives 12–28ms delay to clock-enable logic. G01: CT via 100k to VDD gives 180–420ms reset delay. 0.871V nominal core supervision; worst release <=0.925V. This detects collapse; it does not guarantee the .92V operating minimum. Hold PERST for >=100ms with clock stable. Verify all corners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
0.954V nominal; .588–.612V FB and 0.1% R: 0.934–0.974V. RTL8125BG .92–.98V operating rail, 650mA maximum (Table 29). POW_EXT_SWR controls core startup; do not fit RTL8125BGS here.

Schematic: poe-input.kicad_sch, Isolated PoE — input, TI TIDA-050023 derivative

Parts:
C1707, C1708: 1000pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; TOLERANCE_% 10; PARTNUMBER C1608X7R2A102K
C1709, C1710, C1711, C1712: 330pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; TOLERANCE_% 5; PARTNUMBER 885012006060
D1701, D1702, D1703, D1704: 100V; D_SMB_Handsoldering; PARTNUMBER B2100-13-F
D1705: 58V; D_SMB_Handsoldering; PARTNUMBER SMBJ58A-13-F
D1706, D1707, D1708, D1709: 100V; D_SMB_Handsoldering; PARTNUMBER B2100-13-F; not fitted
L1701, L1703: 300 ohm; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; PARTNUMBER 742792641
L1702: 250uH; TI_WE-SL5; PARTNUMBER 744272251
Q1701, Q1702, Q1703, Q1704: 100V; SuperSOT-3; PARTNUMBER FDN8601
R1709, R1710, R1711, R1712: 1.00Meg; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; TOLERANCE_% 1; PARTNUMBER CRCW06031M00FKEA
R1713, R1714, R1715, R1716: 232k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; TOLERANCE_% 1; PARTNUMBER CRCW0603232KFKEA

Connections:
unnamed: C1707.1, D1701.1 (K), D1702.1 (K), D1703.1 (K), D1704.1 (K), L1702.2
unnamed: C1707.2, C1709.2, C1710.2, C1711.2, C1712.2, D1706.2 (A), D1707.2 (A), D1708.2 (A), D1709.2 (A), L1702.3, Q1701.2 (S), Q1702.2 (S), Q1703.2 (S), Q1704.2 (S), R1713.1, R1714.1, R1715.1, R1716.1
unnamed: L1701.1, L1702.1
unnamed: L1702.4, L1703.1
unnamed: C1709.1, Q1701.1 (G), R1709.1, R1713.2
unnamed: C1710.1, Q1702.1 (G), R1710.1, R1714.2
unnamed: C1711.1, Q1703.1 (G), R1711.1, R1715.2
unnamed: C1712.1, Q1704.1 (G), R1712.1, R1716.2
POE_PAIR12: D1701.2 (A), D1706.1 (K), Q1701.3 (D), R1710.2; also elsewhere on the board
POE_PAIR36: D1702.2 (A), D1707.1 (K), Q1702.3 (D), R1709.2; also elsewhere on the board
POE_PAIR45: D1703.2 (A), D1708.1 (K), Q1703.3 (D), R1712.2; also elsewhere on the board
POE_PAIR78: D1704.2 (A), D1709.1 (K), Q1704.3 (D), R1711.2; also elsewhere on the board
POE_VDD: C1708.1, D1705.1 (K), L1701.2; also elsewhere on the board
POE_VSS: C1708.2, D1705.2 (A), L1703.2; also elsewhere on the board

Notes on the sheet:
Project Title:
Contact:
http://www.ti.com
Mod. Date:
© Texas Instruments
Sheet Title:
Drawn By:
Rev:
Engineer:
Cable pair feeds from HX4110NL 2.5G / four-pair 60W ingress. Reference active bridge retained. Permanent VSS1-to-VSS current-link is now a PCB trace. POE_VSS and POE_RTN remain isolated from system GND.
Assembly Variant:
Designed for:
File:
Number:
Orderable:
SVN Rev:
Sheet:
TID #:
Size:
Texas Instruments and/or its licensors do not warrant the accuracy or completeness of this specification or any information contained therein. Texas Instruments and/or its licensors do not warrant that this design will meet the specifications, will be suitable for your application or fit for any pa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
