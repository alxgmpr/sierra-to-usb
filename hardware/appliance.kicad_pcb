# Repository alxgmpr/sierra-to-usb (continued)

## KiCad design hardware/appliance.kicad_pcb (continued)

Schematic: processor.kicad_sch, RK3566 processor — interface and power capture

Parts:
C801, C802, C803, C804, C805, C806, C807, C808, C809, C810, C811, C812, C815, C816, C817, C818, C819, C821: 1uF; C_0402_1005Metric; Tolerance 10%; Voltage Rating 6.3V; MPN CL05B105KQ5NNNC; LCSC C307426
C820: 1nF; C_0402_1005Metric; Tolerance 5%; Voltage Rating 50V; MPN CL05C102JB5NNNC; LCSC C307441
C822, C824: 22uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; Tolerance 10%; Voltage Rating 25V; MPN CL32B226KAJNNNE; LCSC C309062
C823: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Tolerance 10%; Voltage Rating 50V; MPN CL31B106KBHNNNE; LCSC C89632
Q801, Q802: MMBT3904,215; SOT-23_Handsoldering; MPN MMBT3904,215
R801, R802, R804: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0710KL; LCSC C98220
R803, R805: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07100KL; LCSC C14675
SW801: PROCESSOR RECOVERY; SW_SPST_TL3342; Contact Rating 12VDC 50mA; MPN TL3342F160QG; LCSC C2886898
SW802: PROCESSOR / PMIC RESET; SW_SPST_TL3342; Contact Rating 12VDC 50mA; MPN TL3342F160QG; LCSC C2886898
U801: RK3566; Sierra_RK3566_BGA565; MPN RK3566; LCSC C2943786

Connections:
3V3_MAIN: C817.1, U801.1D13 (VCCIO1), U801.1H18 (USB_AVDD1_3V3), U801.1J2 (USB_AVDD2_3V3), U801.1N8 (VCCIO7); also elsewhere on the board
CLK24_IN: U801.AD37 (XIN24M); also elsewhere on the board
DDR_A_CLKN: U801.B5 (AC24); also elsewhere on the board
DDR_A_CLKP: U801.A5 (AC23); also elsewhere on the board
DDR_A_DQS0N: U801.H1 (DDR_DQS0N_A); also elsewhere on the board
DDR_A_DQS0P: U801.H2 (DDR_DQS0P_A); also elsewhere on the board
DDR_A_DQS1N: U801.N2 (DDR_DQS1N_A); also elsewhere on the board
DDR_A_DQS1P: U801.N1 (DDR_DQS1P_A); also elsewhere on the board
DDR_B_CLKN: U801.B7 (AC9); also elsewhere on the board
DDR_B_CLKP: U801.A7 (AC0); also elsewhere on the board
DDR_B_DQS0N: U801.A12 (DDR_DQS0N_B); also elsewhere on the board
DDR_B_DQS0P: U801.A13 (DDR_DQS0P_B); also elsewhere on the board
DDR_B_DQS1N: U801.B17 (DDR_DQS1N_B); also elsewhere on the board
DDR_B_DQS1P: U801.A17 (DDR_DQS1P_B); also elsewhere on the board
DDR_SOC_RZQ: U801.1F3 (DDR_RZQ); also elsewhere on the board
DEBUG_UART_RX: U801.1V19 (GPIO0_D0_u); also elsewhere on the board
DEBUG_UART_TX: U801.1U18 (GPIO0_D1_u); also elsewhere on the board
EMMC_CLK_SOC: U801.A29 (GPIO1_C5_d); also elsewhere on the board
EMMC_CMD: U801.A27 (GPIO1_C4_u); also elsewhere on the board
EMMC_D0: U801.A32 (GPIO1_B4_u); also elsewhere on the board
EMMC_D1: U801.B27 (GPIO1_B5_u); also elsewhere on the board
EMMC_D2: U801.B32 (GPIO1_B6_u); also elsewhere on the board
EMMC_D3: U801.B29 (GPIO1_B7_u); also elsewhere on the board
EMMC_D4: U801.B33 (GPIO1_C0_u); also elsewhere on the board
EMMC_D5: U801.A30 (GPIO1_C1_u); also elsewhere on the board
EMMC_D6: U801.B30 (GPIO1_C2_u); also elsewhere on the board
EMMC_D7: U801.A33 (GPIO1_C3_u); also elsewhere on the board
EMMC_RESET_N: U801.1B16 (GPIO1_C7_d); also elsewhere on the board
EMMC_STROBE: U801.1A16 (GPIO1_C6_d); also elsewhere on the board
FLASH_VOL_SEL: U801.AF38 (GPIO0_A7_u); also elsewhere on the board
FSPI_CLK: U801.1A15 (GPIO1_D0_d); also elsewhere on the board
FSPI_CS0_N: U801.1B17 (GPIO1_D3_u); also elsewhere on the board
FSPI_D0: U801.1A17 (GPIO1_D1_u); also elsewhere on the board
FSPI_D1: U801.1A18 (GPIO1_D2_u); also elsewhere on the board
FSPI_D3: U801.1C15 (GPIO1_D4_u); also elsewhere on the board
GND: C801.2, C802.2, C803.2, C804.2, C805.2, C806.2, C807.2, C808.2, C809.2, C810.2, C811.2, C812.2, C815.2, C816.2, C817.2, C818.2, C819.2, C820.2, C821.2, C822.2, C823.2, C824.2, Q801.2 (E), Q802.2 (E), R803.2, R805.2, SW801.2, SW802.2, U801.1A19 (SARADC_VIN3), U801.1B10 (VSS_30), U801.1B11 (VSS_31), U801.1B15 (VSS_32), U801.1B18 (SARADC_VIN2), U801.1B19 (VSS_33), U801.1C4 (VSS_34), U801.1C5 (VSS_35), U801.1C6 (VSS_36), U801.1C8 (VSS_37), U801.1C9 (VSS_38), U801.1C14 (VSS_39), U801.1C16 (VSS_40), U801.1C17 (SARADC_VIN1), U801.1C18 (VSS_41), U801.1D1 (VSS_42), U801.1D3 (VSS_43), U801.1D4 (DDR_AVSS), U801.1D10 (VSS_44), U801.1D14 (VSS_45), U801.1E3 (VSS_46), U801.1E8 (VSS_47), U801.1E10 (VSS_48), U801.1E14 (VSS_49), U801.1E15 (VSS_50), U801.1E17 (VSS_51), U801.1F6 (VSS_52), U801.1F7 (VSS_53), U801.1F8 (VSS_54), U801.1F9 (VSS_55), U801.1F10 (VSS_56), U801.1F15 (VSS_57), U801.1F16 (VSS_58), U801.1F20 (AVSS1_6), U801.1G3 (VSS_59), U801.1G6 (VSS_60), U801.1G7 (VSS_61), U801.1G8 (VSS_62), U801.1G9 (VSS_63), U801.1G10 (VSS_64), U801.1G11 (VSS_65), U801.1G12 (VSS_66), U801.1G14 (VSS_67), U801.1G16 (AVSS1_7), U801.1G18 (AVSS1_8), U801.1G19 (AVSS1_9), U801.1G20 (AVSS1_10), U801.1H1 (VSS_68), U801.1H2 (VSS_69), U801.1H6 (VSS_70), U801.1H11 (VSS_71), U801.1H12 (VSS_72), U801.1H13 (VSS_73), U801.1J1 (VSS_74), U801.1J5 (SYSPLL_AVSS), U801.1J6 (VSS_75), U801.1J8 (VSS_76), U801.1J9 (VSS_77), U801.1J11 (VSS_78), U801.1J12 (VSS_79), U801.1J13 (VSS_80), U801.1J16 (AVSS1_11), U801.1J18 (AVSS1_12), U801.1K2 (VSS_81), U801.1K3 (VSS_82), U801.1K4 (VSS_83), U801.1K5 (VSS_84), U801.1K6 (VSS_85), U801.1K8 (VSS_86), U801.1K9 (VSS_87), U801.1K11 (VSS_88), U801.1K12 (VSS_89), U801.1K13 (VSS_90), U801.1K14 (VSS_91), U801.1K15 (VSS_92), U801.1K18 (AVSS1_13), U801.1L3 (VSS_93), U801.1L6 (VSS_94), U801.1L10 (VSS_95), U801.1L11 (VSS_96), U801.1L12 (VSS_97), U801.1L13 (VSS_98), U801.1L14 (VSS_99), U801.1L15 (VSS_100), U801.1L19 (AVSS1_14), U801.1M3 (VSS_101), U801.1M4 (VSS_102), U801.1M5 (VSS_103), U801.1M6 (VSS_104), U801.1M10 (VSS_105), U801.1M11 (VSS_106), U801.1M12 (VSS_107), U801.1M13 (VSS_108), U801.1M14 (VSS_109), U801.1M15 (VSS_110), U801.1M16 (VSS_111), U801.1M17 (VSS_112), U801.1M20 (VSS_113), U801.1N3 (VSS_114), U801.1N4 (VSS_115), U801.1N7 (VSS_116), U801.1N11 (AVSS_9), U801.1N12 (AVSS_10), U801.1N17 (PMUPLL_AVSS), U801.1P1 (VSS_117), U801.1P5 (VSS_118), U801.1P6 (VSS_119), U801.1P7 (VSS_120), U801.1P8 (AVSS_11), U801.1P10 (AVSS_12), U801.1P14 (AVSS_13), U801.1P15 (VSS_121), U801.1R3 (VSS_122), U801.1R4 (VSS_123), U801.1R5 (VSS_124), U801.1R6 (VSS_125), U801.1R7 (VSS_126), U801.1R8 (AVSS_14), U801.1R9 (AVSS_15), U801.1R11 (AVSS_16), U801.1R12 (AVSS_17), U801.1R13 (AVSS_18), U801.1R14 (AVSS_19), U801.1R15 (AVSS_20), U801.1T3 (VSS_127), U801.1T5 (VSS_128), U801.1T7 (AVSS_21), U801.1T8 (AVSS_22), U801.1T9 (AVSS_23), U801.1T10 (AVSS_24), U801.1T11 (AVSS_25), U801.1T12 (AVSS_26), U801.1T13 (AVSS_27), U801.1T14 (AVSS_28), U801.1T15 (AVSS_29), U801.1T16 (AVSS_30), U801.1T17 (AVSS_31), U801.1U2 (VSS_129), U801.1U12 (AVSS_32), U801.1U13 (AVSS_33), U801.1U15 (AVSS_34), U801.1U17 (AVSS_35), U801.1V1 (VSS_130), U801.1V4 (VSS_131), U801.1V7 (AVSS_36), U801.1V12 (AVSS_37), U801.1V13 (AVSS_38), U801.1V18 (AVSS_39), U801.A1 (VSS_1), U801.A2 (VSS_2), U801.A38 (VSS_3), U801.AA2 (VSS_18), U801.AC37 (VSS_24), U801.AD2 (VSS_19), U801.AE37 (VSS_25), U801.AH37 (VSS_26), U801.AL37 (VSS_27), U801.AP2 (VSS_20), U801.AP8 (VSS_22), U801.AP13 (AVSS_1), U801.AP16 (AVSS_2), U801.AP19 (AVSS_3), U801.AP22 (AVSS_4), U801.AP25 (AVSS_5), U801.AP28 (AVSS_6), U801.AP31 (AVSS_7), U801.AP34 (AVSS_8), U801.AP37 (VSS_28), U801.AR1 (VSS_21), U801.AR38 (VSS_29), U801.B1 (VSS_4), U801.B2 (VSS_5), U801.B6 (VSS_6), U801.B11 (VSS_7), U801.B14 (VSS_8), U801.B18 (VSS_9), U801.B21 (VSS_10), U801.B28 (VSS_11), U801.B31 (VSS_12), U801.D2 (VSS_13), U801.E37 (VSS_23), U801.H37 (AVSS1_1), U801.J2 (VSS_14), U801.L2 (VSS_15), U801.L37 (AVSS1_2), U801.P37 (AVSS1_3), U801.U2 (VSS_16), U801.U37 (AVSS1_4), U801.W2 (VSS_17), U801.Y37 (AVSS1_5); also elsewhere on the board
LPDDR4_A0_A: U801.C2 (AC11); also elsewhere on the board
LPDDR4_A0_B: U801.A9 (AC13); also elsewhere on the board
LPDDR4_A1_A: U801.C1 (AC2); also elsewhere on the board
LPDDR4_A1_B: U801.B9 (AC6); also elsewhere on the board
LPDDR4_A2_A: U801.1C1 (AC15); also elsewhere on the board
LPDDR4_A2_B: U801.1B7 (AC18); also elsewhere on the board
LPDDR4_A3_A: U801.1B3 (AC12); also elsewhere on the board
LPDDR4_A3_B: U801.1B6 (AC4); also elsewhere on the board
LPDDR4_A4_A: U801.1B1 (AC14); also elsewhere on the board
LPDDR4_A4_B: U801.1A6 (AC19); also elsewhere on the board
LPDDR4_A5_A: U801.1A1 (AC16); also elsewhere on the board
LPDDR4_A5_B: U801.B8 (AC5); also elsewhere on the board
LPDDR4_CKE0_A: U801.B4 (AC22); also elsewhere on the board
LPDDR4_CKE0_B: U801.1A3 (AC10); also elsewhere on the board
LPDDR4_CS0n_A: U801.B3 (AC25); also elsewhere on the board
LPDDR4_CS0n_B: U801.1B5 (AC28); also elsewhere on the board
LPDDR4_DM0_A: U801.1E2 (DDR_DM0_A); also elsewhere on the board
LPDDR4_DM0_B: U801.1B8 (DDR_DM0_B); also elsewhere on the board
LPDDR4_DM1_A: U801.1G1 (DDR_DM1_A); also elsewhere on the board
LPDDR4_DM1_B: U801.1A11 (DDR_DM1_B); also elsewhere on the board
LPDDR4_DQ0_A: U801.G2 (DDR_DQ0_A); also elsewhere on the board
LPDDR4_DQ0_B: U801.B12 (DDR_DQ0_B); also elsewhere on the board
LPDDR4_DQ1_A: U801.F2 (DDR_DQ1_A); also elsewhere on the board
LPDDR4_DQ1_B: U801.B10 (DDR_DQ1_B); also elsewhere on the board
LPDDR4_DQ2_A: U801.F1 (DDR_DQ2_A); also elsewhere on the board
LPDDR4_DQ2_B: U801.1A8 (DDR_DQ2_B); also elsewhere on the board
LPDDR4_DQ3_A: U801.E1 (DDR_DQ3_A); also elsewhere on the board
LPDDR4_DQ3_B: U801.1A7 (DDR_DQ3_B); also elsewhere on the board
LPDDR4_DQ4_A: U801.M2 (DDR_DQ4_A); also elsewhere on the board
LPDDR4_DQ4_B: U801.B13 (DDR_DQ4_B); also elsewhere on the board
LPDDR4_DQ5_A: U801.K1 (DDR_DQ5_A); also elsewhere on the board
LPDDR4_DQ5_B: U801.1A10 (DDR_DQ5_B); also elsewhere on the board
LPDDR4_DQ6_A: U801.K2 (DDR_DQ6_A); also elsewhere on the board
LPDDR4_DQ6_B: U801.1B9 (DDR_DQ6_B); also elsewhere on the board
LPDDR4_DQ7_A: U801.1E1 (DDR_DQ7_A); also elsewhere on the board
LPDDR4_DQ7_B: U801.1A9 (DDR_DQ7_B); also elsewhere on the board
LPDDR4_DQ8_A: U801.P2 (DDR_DQ8_A); also elsewhere on the board
LPDDR4_DQ8_B: U801.B19 (DDR_DQ8_B); also elsewhere on the board
LPDDR4_DQ9_A: U801.R1 (DDR_DQ9_A); also elsewhere on the board
LPDDR4_DQ9_B: U801.A19 (DDR_DQ9_B); also elsewhere on the board
LPDDR4_DQ10_A: U801.R2 (DDR_DQ10_A); also elsewhere on the board
LPDDR4_DQ10_B: U801.A20 (DDR_DQ10_B); also elsewhere on the board
LPDDR4_DQ11_A: U801.T2 (DDR_DQ11_A); also elsewhere on the board
LPDDR4_DQ11_B: U801.B20 (DDR_DQ11_B); also elsewhere on the board
LPDDR4_DQ12_A: U801.M1 (DDR_DQ12_A); also elsewhere on the board
LPDDR4_DQ12_B: U801.A15 (DDR_DQ12_B); also elsewhere on the board
LPDDR4_DQ13_A: U801.1F2 (DDR_DQ13_A); also elsewhere on the board
LPDDR4_DQ13_B: U801.B15 (DDR_DQ13_B); also elsewhere on the board
LPDDR4_DQ14_A: U801.1F1 (DDR_DQ14_A); also elsewhere on the board
LPDDR4_DQ14_B: U801.1C10 (DDR_DQ14_B); also elsewhere on the board
LPDDR4_DQ15_A: U801.1G2 (DDR_DQ15_A); also elsewhere on the board
LPDDR4_DQ15_B: U801.B16 (DDR_DQ15_B); also elsewhere on the board
LPDDR4_RESETn: U801.1C7 (AC29); also elsewhere on the board
MCU_PROCESSOR_RECOVERY_ASSERT: R804.1; also elsewhere on the board
MCU_PROCESSOR_RESET_ASSERT: R802.1; also elsewhere on the board
MODEM_USB_D_N: U801.1J20 (USB3_HOST1_DM); also elsewhere on the board
MODEM_USB_D_P: U801.1J19 (USB3_HOST1_DP); also elsewhere on the board
MODEM_USB_RXN: U801.V37 (USB3_HOST1_SSRXN); also elsewhere on the board
MODEM_USB_RXP: U801.V38 (USB3_HOST1_SSRXP); also elsewhere on the board
MODEM_USB_SOC_TXN: U801.W38 (USB3_HOST1_SSTXN); also elsewhere on the board
MODEM_USB_SOC_TXP: U801.W37 (USB3_HOST1_SSTXP); also elsewhere on the board
MULTI_AVDD_0V9: U801.1K16 (MULTI_PHY_AVDD_0V9); also elsewhere on the board
MULTI_AVDD_1V8: U801.1K17 (MULTI_PHY_AVDD_1V8); also elsewhere on the board
unnamed: Q801.1 (B), R802.2, R803.1
unnamed: Q802.1 (B), R804.2, R805.1
PCIE_CLKREQ_N: U801.AG37 (GPIO0_A5_d); also elsewhere on the board
PCIE_PERST_SOC_N: U801.1R16 (GPIO0_B6_u); also elsewhere on the board
PCIE_REFCLK_N: U801.1K20 (PCIE20_REFCLKN); also elsewhere on the board
PCIE_REFCLK_P: U801.1K19 (PCIE20_REFCLKP); also elsewhere on the board
PCIE_SOC_RXN: U801.AB38 (PCIE20_RXN); also elsewhere on the board
PCIE_SOC_RXP: U801.AB37 (PCIE20_RXP); also elsewhere on the board
PCIE_SOC_TXN: U801.AA38 (PCIE20_TXN); also elsewhere on the board
PCIE_SOC_TXP: U801.AA37 (PCIE20_TXP); also elsewhere on the board
PCIE_WAKE_N: U801.1U20 (GPIO0_B5_u); also elsewhere on the board
PMIC_I2C_SCL: U801.AJ37 (GPIO0_B1_u); also elsewhere on the board
PMIC_I2C_SDA: U801.AK38 (GPIO0_B2_u); also elsewhere on the board
PMIC_INT_N: U801.1R19 (GPIO0_A3_u); also elsewhere on the board
PMIC_SLEEP: U801.1P19 (GPIO0_A2_d); also elsewhere on the board
RECOVERY_USB_D_N: U801.R38 (USB_OTG0_DM); also elsewhere on the board
RECOVERY_USB_D_P: U801.R37 (USB_OTG0_DP); also elsewhere on the board
RECOVERY_VBUS_DET: U801.T38 (USB_OTG0_VBUSDET); also elsewhere on the board
RK_RESET_N: Q801.3 (C), SW802.1, U801.AG38 (nPOR_u); also elsewhere on the board
SARADC_BOOT_KEY: C820.1, Q802.3 (C), R801.2, SW801.1, U801.1D17 (SARADC_VIN0); also elsewhere on the board
SDMMC0_DET: U801.AF37 (GPIO0_A4_u); also elsewhere on the board
SD_CLK_SOC: U801.G38 (GPIO2_A2_d); also elsewhere on the board
SD_CMD: U801.1E19 (GPIO2_A1_u); also elsewhere on the board
SD_D0: U801.1E20 (GPIO1_D5_u); also elsewhere on the board
SD_D1: U801.1F19 (GPIO1_D6_u); also elsewhere on the board
SD_D2: U801.1D20 (GPIO1_D7_u); also elsewhere on the board
SD_D3: U801.1F18 (GPIO2_A0_u); also elsewhere on the board
SD_PWR_EN: U801.AJ38 (GPIO0_A6_d); also elsewhere on the board
SOC_HEALTH: U801.AN37 (GPIO0_C4_d); also elsewhere on the board
SOC_LINK_RX: U801.A22 (GPIO1_A0_u); also elsewhere on the board
SOC_LINK_TX: U801.B22 (GPIO1_A1_u); also elsewhere on the board
TSADC_SHUTDOWN: U801.1R20 (GPIO0_A1_z); also elsewhere on the board
USB2_AVDD_0V9: U801.1J4 (USB_AVDD2_0V9); also elsewhere on the board
USB2_AVDD_1V8: U801.1J3 (USB_AVDD2_1V8); also elsewhere on the board
USB_AVDD_0V9: C815.1, U801.1J17 (USB_AVDD1_0V9); also elsewhere on the board
USB_AVDD_1V8: C816.1, U801.1H16 (USB_AVDD1_1V8); also elsewhere on the board
VCC3V3_PMU: C811.1, C812.1, U801.1N15 (PMUIO2), U801.1P16 (PMUIO1); also elsewhere on the board
VCCA1V8_PMU: C803.1, C804.1, U801.1N18 (PMUPLL_AVDD_1V8); also elsewhere on the board
VCCA_1V8: C807.1, C808.1, C818.1, C819.1, R801.1, U801.1D15 (OTP_VCC18), U801.1D16 (SARADC_AVDD_1V8), U801.1G17 (EDP_TX_AVDD_1V8), U801.1H4 (SYSPLL_AVDD_1V8), U801.1P9 (MIPI_CSI_RX_AVDD_1V8), U801.1P12 (MIPI_DSI_TX0_AVDD_1V8), U801.1P13 (HDMI_TX_AVDD_1V8), U801.1R10 (MIPI_DSI_TX1_AVDD_1V8); also elsewhere on the board
VCCIO_SD: U801.1F17 (VCCIO3); also elsewhere on the board
VCC_1V8: U801.1C13 (VCCIO2), U801.1E16 (VCCIO4), U801.1L4 (VCCIO6_1), U801.1L5 (VCCIO6_2), U801.1N5 (VCCIO5_1), U801.1N6 (VCCIO5_2); also elsewhere on the board
VDDA0V9_PMU: C801.1, C802.1, C809.1, C810.1, U801.1N16 (PMU_VDD_LOGIC_0V9), U801.1P17 (PMUPLL_AVDD_0V9); also elsewhere on the board
VDDA_0V9: C805.1, C806.1, U801.1H5 (SYSPLL_AVDD_0V9), U801.1H17 (EDP_TX_AVDD_0V9), U801.1N9 (MIPI_CSI_RX_AVDD_0V9), U801.1N10 (MIPI_DSI_TX1_AVDD_0V9), U801.1N13 (HDMI_TX_AVDD_0V9_2), U801.1N14 (HDMI_TX_AVDD_0V9_1), U801.1P11 (MIPI_DSI_TX0_AVDD_0V9); also elsewhere on the board
VDD_CPU: U801.1C12 (VDD_CPU_1), U801.1D11 (VDD_CPU_2), U801.1D12 (VDD_CPU_3), U801.1E11 (VDD_CPU_4), U801.1E12 (VDD_CPU_5), U801.1E13 (VDD_CPU_6), U801.1F11 (VDD_CPU_7), U801.1F12 (VDD_CPU_8), U801.1F13 (VDD_CPU_9), U801.1F14 (VDD_CPU_10), U801.1G13 (VDD_CPU_11); also elsewhere on the board
VDD_DDR_0V6: U801.1E6 (DDRPHY_VDDQL_1), U801.1E7 (DDRPHY_VDDQL_2), U801.1E9 (DDRPHY_VDDQL_3), U801.1F5 (DDRPHY_VDDQL_4), U801.1G5 (DDRPHY_VDDQL_5); also elsewhere on the board
VDD_DDR_1V1: U801.1D5 (DDRPHY_VDDQ_1), U801.1D6 (DDRPHY_VDDQ_2), U801.1D7 (DDRPHY_VDDQ_3), U801.1D8 (DDRPHY_VDDQ_4), U801.1D9 (DDRPHY_VDDQ_5), U801.1E4 (DDRPHY_VDDQ_6), U801.1F4 (DDRPHY_VDDQ_7), U801.1G4 (DDRPHY_VDDQ_8); also elsewhere on the board
VDD_GPU: U801.1L8 (VDD_GPU_1), U801.1L9 (VDD_GPU_2), U801.1M7 (VDD_GPU_3), U801.1M8 (VDD_GPU_4), U801.1M9 (VDD_GPU_5); also elsewhere on the board
VDD_LOGIC: U801.1H7 (VDD_LOGIC_1), U801.1H8 (VDD_LOGIC_2), U801.1H9 (VDD_LOGIC_3), U801.1H10 (VDD_LOGIC_4), U801.1J7 (VDD_LOGIC_5), U801.1J10 (VDD_LOGIC_6), U801.1K7 (VDD_LOGIC_7), U801.1K10 (VDD_LOGIC_8), U801.1L7 (VDD_LOGIC_9); also elsewhere on the board
VDD_NPU: C821.1, C822.1, C823.1, C824.1, U801.1G15 (VDD_NPU_1), U801.1H14 (VDD_NPU_2), U801.1H15 (VDD_NPU_3), U801.1J14 (VDD_NPU_4), U801.1J15 (VDD_NPU_5); also elsewhere on the board

Notes on the sheet:
PROCESSOR: 565 balls captured. CPU/eMMC/PCIe/USB and PMIC controls connected. Unused GPIO/analog signal balls are NC; disabled peripherals must remain disabled in firmware. TVSS and XOUT24M float per reference; 1.8V active oscillator feeds XIN24M. 1.8V flash strap, debug strap and thermal-shutdown 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

Schematic: recovery.kicad_sch, Independent recovery core — architecture gate open

Parts:
J101: 3.3V RAIL TEST; Wuerth_61300211121_1x02_P2.54mm_Vertical; MPN 61300211121
J102: CONTROL BOUNDARY; Wuerth_61301011121_1x10_P2.54mm_Vertical; MPN 61301011121

Connections:
+3V3: J101.1; also elsewhere on the board
/Recovery and always-on supply/POWER_FAULT_N: J102.9; also elsewhere on the board
/Recovery and always-on supply/SERVICE_RX: J102.7; also elsewhere on the board
/Recovery and always-on supply/SERVICE_TX: J102.6; also elsewhere on the board
ETH_PERST_N: J102.5; also elsewhere on the board
GND: J101.2, J102.10; also elsewhere on the board
MCU_ETH_POWER_EN: J102.2; also elsewhere on the board
MCU_HEALTH_IN: J102.8; also elsewhere on the board
MCU_MODEM_POWER_EN: J102.1; also elsewhere on the board
MODEM_OFF_N: J102.4; also elsewhere on the board
MODEM_RESET_N: J102.3; also elsewhere on the board

Notes on the sheet:
Service UART / health / fault inputs: 3.3V only. Add powered-off-safe translation when target voltage requires it. Service UART must not back-power target. No MCU modem-session interface is implemented.
SCOPE OF THIS SCHEMATIC MILESTONE
3.3V rail test; do not back-power. No PoE or unisolated input here.
Implemented: MCU, independent watchdog/brownout, SWD, manual reset, open-collector control outputs and default-off enables. Not implemented: packet processor, PoE/isolation, modem socket/SIM, high-current regulators or Ethernet. NOT a complete WAN appliance. J101 is a 3.3V rail test header; J102 is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

Schematic: ethernet-ingress.kicad_sch, 2.5GbE cable ingress and four-pair PoE extraction

Parts:
C1851, C1852, C1853, C1854: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Tolerance 10%; Voltage Rating 25V; MPN CL10B104KA8NNNC; LCSC C1590
C1861, C1862, C1863, C1864: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 100V; Tolerance 10%; MPN C1608X7R2A103K
C1865: 1nF / 2kV; C_1808_4520Metric_Pad1.72x2.30mm_HandSolder; Voltage Rating 2kV; MPN GR442QR73D102KW01L
D1851, D1852: TPD4E02B04DQAR; USON-10_2.5x1.0mm_P0.5mm; Working Voltage -3.6 to +3.6V; MPN TPD4E02B04DQAR; LCSC C106794
J1701: 2.5GbE + PoE; Sierra_RJE491881401_1x08-1MP_P1.02mm; Current Rating 1.25A per contact; MPN RJE491881401
R1861, R1862, R1863, R1864: 75R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN CRCW060375R0FKEA
T1701: HX4110NLT; Sierra_HX4110NL_2x12_P1.27mm; PoE Rating 4-pair 60W (manufacturer product finder); MPN HX4110NLT

Connections:
BOB_SMITH_COMMON: C1865.1, R1861.2, R1862.2, R1863.2, R1864.2
BS_PAIR0: C1861.2, R1861.1
BS_PAIR1: C1862.2, R1862.1
BS_PAIR2: C1863.2, R1863.1
BS_PAIR3: C1864.2, R1864.1
CABLE_MDI0_N: J1701.2, T1701.22 (MX1-)
CABLE_MDI0_P: J1701.1, T1701.23 (MX1+)
CABLE_MDI1_N: J1701.6, T1701.19 (MX2-)
CABLE_MDI1_P: J1701.3, T1701.20 (MX2+)
CABLE_MDI2_N: J1701.5, T1701.16 (MX3-)
CABLE_MDI2_P: J1701.4, T1701.17 (MX3+)
CABLE_MDI3_N: J1701.8, T1701.13 (MX4-)
CABLE_MDI3_P: J1701.7, T1701.14 (MX4+)
CHASSIS: C1865.2, J1701.SH
ETH_CT0: C1851.1, T1701.1 (TCT1)
ETH_CT1: C1852.1, T1701.4 (TCT2)
ETH_CT2: C1853.1, T1701.7 (TCT3)
ETH_CT3: C1854.1, T1701.10 (TCT4)
ETH_MDI0_N: D1851.2 (IO2), D1851.9 (FT2), T1701.3 (TD1-); also elsewhere on the board
ETH_MDI0_P: D1851.1 (IO1), D1851.10 (FT1), T1701.2 (TD1+); also elsewhere on the board
ETH_MDI1_N: D1851.5 (IO4), D1851.6 (FT4), T1701.6 (TD2-); also elsewhere on the board
ETH_MDI1_P: D1851.4 (IO3), D1851.7 (FT3), T1701.5 (TD2+); also elsewhere on the board
ETH_MDI2_N: D1852.2 (IO2), D1852.9 (FT2), T1701.9 (TD3-); also elsewhere on the board
ETH_MDI2_P: D1852.1 (IO1), D1852.10 (FT1), T1701.8 (TD3+); also elsewhere on the board
ETH_MDI3_N: D1852.5 (IO4), D1852.6 (FT4), T1701.12 (TD4-); also elsewhere on the board
ETH_MDI3_P: D1852.4 (IO3), D1852.7 (FT3), T1701.11 (TD4+); also elsewhere on the board
GND: C1851.2, C1852.2, C1853.2, C1854.2, D1851.3 (GND), D1851.8 (GND), D1852.3 (GND), D1852.8 (GND); also elsewhere on the board
POE_PAIR12: C1861.1, T1701.24 (MCT4); also elsewhere on the board
POE_PAIR36: C1862.1, T1701.21 (MCT2); also elsewhere on the board
POE_PAIR45: C1863.1, T1701.18 (MCT3); also elsewhere on the board
POE_PAIR78: C1864.1, T1701.15 (MCT4); also elsewhere on the board

Notes on the sheet:
T1701 pin/polarity and four center taps audited to Pulse page 2. PHY CTs: one 100nF to GND each, following RTL8125BG reference. Cable CTs feed active PoE bridge; 10nF series caps block PoE DC in Bob-Smith termination. CHASSIS is RJ45 shell/enclosure only. No copper connection across magnetics or to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

Schematic: aux-power.kicad_sch, Auxiliary 12 V input, ideal-diode OR and bus monitor

Parts:
C2101, C2104, C2105: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Tolerance 10%; Voltage Rating 50V; MPN CL31B106KBHNNNE; LCSC C89632
C2102, C2103, C2106, C2107: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Tolerance 10%; Voltage Rating 25V; MPN CL10B104KA8NNNC; LCSC C1590
D2101: SMBJ12CA; D_SMB_Handsoldering; MPN SMBJ12CA
J2101: ED555/2DS; TI_TERM_BLK_ED555-2DS; MPN ED555/2DS
Q2101, Q2102: CSD17577Q5A; TDSON-8-1; MPN CSD17577Q5A; LCSC C475504
R2101: 10mR; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder; Tolerance 1%; Power Rating 2W; MPN PE2512FKE7W0R01L; LCSC C875720
R2102, R2103: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-074K7L
R2104, R2106: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0710KL
R2105: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07100KL
U2101, U2102: LM74700QDBVRQ1; SOT-23-6_Handsoldering; MPN LM74700QDBVRQ1; LCSC C2941042
U2103: INA226AIDGSR; MSOP-10_3x3mm_P0.5mm; MPN INA226AIDGSR; LCSC C49851

Connections:
+3V3: C2106.1, R2102.1, R2103.1, R2104.1, U2103.6 (VS); also elsewhere on the board
ADC_AUX_12V: C2107.1, R2105.2, R2106.1; also elsewhere on the board
AUX_12V_IN: C2101.1, C2102.2, D2101.1 (A1), J2101.1, Q2101.1 (S), Q2101.2 (S), Q2101.3 (S), R2105.1, U2101.3 (EN), U2101.6 (ANODE); also elsewhere on the board
AUX_DIODE_GATE: Q2101.4 (G), U2101.5 (GATE)
AUX_DIODE_VCAP: C2102.1, U2101.1 (VCAP)
GND: C2101.2, C2104.2, C2105.2, C2106.2, C2107.2, D2101.2 (A2), J2101.2, R2106.2, U2101.2 (GND), U2102.2 (GND), U2103.1 (A1), U2103.2 (A0), U2103.7 (GND); also elsewhere on the board
ISO_12V: R2101.2, U2103.8 (Vbus), U2103.9 (Vin-); also elsewhere on the board
ISO_12V_BUS: C2104.1, C2105.1, Q2101.5 (D), Q2102.5 (D), R2101.1, U2101.4 (CATHODE), U2102.4 (CATHODE), U2103.10 (Vin+); also elsewhere on the board
ISO_12V_PSU: C2103.2, Q2102.1 (S), Q2102.2 (S), Q2102.3 (S), U2102.3 (EN), U2102.6 (ANODE); also elsewhere on the board
MON_ALERT_N: R2104.2, U2103.3 (~Alert); also elsewhere on the board
MON_I2C_SCL: R2102.2, U2103.5 (SCL); also elsewhere on the board
MON_I2C_SDA: R2103.2, U2103.4 (SDA); also elsewhere on the board
PSU_DIODE_GATE: Q2102.4 (G), U2102.5 (GATE)
PSU_DIODE_VCAP: C2103.1, U2102.1 (VCAP)

Notes on the sheet:
AUX 12 V INPUT AND IDEAL-DIODE OR WITH THE ISOLATED FLYBACK
Either source feeds ISO_12V_BUS through its own LM74700 ideal diode; the higher one carries the load. Aux input: 12 V nominal, 12.6 V max (SMBJ12CA starts conducting at 13.3 V; TPS54620 input limit 17 V). Reverse aux polarity: the TVS conducts and LM74700 blocks; fuse or current-limit the bench sup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
12 V BUS CURRENT AND VOLTAGE MONITOR
ADC_AUX_12V = AUX_12V_IN / 11 (12 V -> 1.09 V) on STM32 PA0. INA226 runs from the always-on 3.3 V.

Schematic: management.kicad_sch, Supervisor link, status LEDs and sensing

Parts:
C2201, C2202, C2203, C2204, C2205, C2207, C2208: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Tolerance 10%; Voltage Rating 25V; MPN CL10B104KA8NNNC; LCSC C1590
C2206: 1nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Tolerance 10%; Voltage Rating 100V; MPN C1608X7R2A102K
D2201, D2202, D2203: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN 150060GS75000; LCSC C5252984
D2204: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN 150060YS75000
R2201, R2202, R2207, R2208, R2209, R2210, R2211, R2212, R2213: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07100KL
R2203, R2204, R2205, R2206: 1kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-071KL
R2214, R2215: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0710KL
RT2201, RT2202: 10k B3380; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN NCP18XH103F03RB; LCSC C13564
U2201, U2202: SN74LVC1G125DCKR; SOT-353_SC-70-5; MPN SN74LVC1G125DCKR; LCSC C7833

Connections:
3V3_MAIN: C2202.1, R2201.1, R2209.1, U2202.5 (VCC); also elsewhere on the board
5V_MAIN: R2207.1; also elsewhere on the board
+3V3: C2201.1, R2202.1, R2203.1, R2204.1, R2205.1, R2206.1, R2214.1, R2215.1, U2201.5 (VCC); also elsewhere on the board
ADC_3V3_MAIN: C2204.1, R2209.2, R2210.1; also elsewhere on the board
ADC_5V_MAIN: C2203.1, R2207.2, R2208.1; also elsewhere on the board
ADC_MODEM_ILM: C2206.1, R2213.2; also elsewhere on the board
ADC_MODEM_VCC: C2205.1, R2211.2, R2212.1; also elsewhere on the board
ADC_NTC_MODEM: C2207.1, R2214.2, RT2201.1; also elsewhere on the board
ADC_NTC_POWER: C2208.1, R2215.2, RT2202.1; also elsewhere on the board
GND: C2201.2, C2202.2, C2203.2, C2204.2, C2205.2, C2206.2, C2207.2, C2208.2, R2208.2, R2210.2, R2212.2, RT2201.2, RT2202.2, U2201.1, U2201.3 (GND), U2202.1, U2202.3 (GND); also elsewhere on the board
LED_FAULT_A: D2204.2 (A), R2206.2
LED_FAULT_N: D2204.1 (K); also elsewhere on the board
LED_PWR_A: D2201.2 (A), R2203.2
LED_PWR_N: D2201.1 (K); also elsewhere on the board
LED_SYS_A: D2202.2 (A), R2204.2
LED_SYS_N: D2202.1 (K); also elsewhere on the board
LED_WAN_A: D2203.2 (A), R2205.2
LED_WAN_N: D2203.1 (K); also elsewhere on the board
MCU_LINK_RX: U2201.4; also elsewhere on the board
MCU_LINK_TX: R2202.2, U2202.2; also elsewhere on the board
MODEM_FUSE_ILM: R2213.1; also elsewhere on the board
MODEM_VCC: R2211.1; also elsewhere on the board
SOC_LINK_RX: U2202.4; also elsewhere on the board
SOC_LINK_TX: R2201.2, U2201.2; also elsewhere on the board

Notes on the sheet:
POWERED-OFF-SAFE SOC <-> STM32 UART (SoC UART3_M0, MCU LPUART2)
Each buffer is powered by its receiving side: SoC->MCU from +3V3, MCU->SoC from 3V3_MAIN. SoC: A22 UART3_RX_M0 / B22 UART3_TX_M0, VCCIO1 = 3V3_MAIN. MCU: PC7 LPUART2_RX / PC6 LPUART2_TX. Carries telemetry, LED overrides, power-cycle requests and reset-cause reporting.
STATUS LEDS: MCU-DRIVEN, LINUX OVERRIDE OVER THE LINK
LEDs are off from MCU reset until firmware drives them; Linux can override each over the UART link. ~1.3 mA each from 3.3 V through 1 kOhm.
ANALOG MONITORS ON THE STM32 ADC (VREF+ = +3V3)
PA1 ADC_5V_MAIN = 5V/2, PA4 ADC_3V3_MAIN = 3V3/2, PA5 ADC_MODEM_VCC = VCC/2, PA6 ADC_MODEM_ILM, PA7 ADC_NTC_MODEM, PB2 ADC_NTC_POWER (10k NTC to GND, 10k pull-up: ratiometric to VREF+). ILM: TPS25947 analog current monitor (V = I_OUT x G_IMON x R_ILM). Its pin must see < 50 pF: place R2213 at U1902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

Schematic: boot-media.kicad_sch, SPI boot flash, microSD and eSIM options

Parts:
C2301: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Tolerance 10%; Voltage Rating 25V; MPN CL10B104KA8NNNC; LCSC C1590
C2302: 1nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Tolerance 10%; Voltage Rating 100V; MPN C1608X7R2A102K; not fitted
C2303: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Voltage Rating 25V; MPN CL10A475KA8NQNC; not fitted
C2304, C2305: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Tolerance 10%; Voltage Rating 25V; MPN CL10B104KA8NNNC; LCSC C1590; not fitted
D2301, D2302: TPD4E02B04DQAR; USON-10_2.5x1.0mm_P0.5mm; MPN TPD4E02B04DQAR; LCSC C106794; not fitted
J2301: DM3AT-SF-PEJM5; microSD_HC_Hirose_DM3AT-SF-PEJM5; MPN DM3AT-SF-PEJM5; LCSC C114218; not fitted
R2301, R2302, R2303: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0710KL
R2304: 22R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0722RL; not fitted
R2305, R2306, R2307, R2308, R2309: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-0710KL; not fitted
R2310: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 1%; Power Rating 0.1W; MPN RC0603FR-07100KL; not fitted
R2311, R2312, R2313, R2314: 0R ESIM / DNP; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Tolerance 5%; Power Rating 0.1W; MPN RC0603JR-070RL; not fitted
U2301: W25Q128JWEIQ; WSON-8-1EP_8x6mm_P1.27mm_EP3.4x4.3mm; MPN W25Q128JWEIQ
U2302: TPS22965DSGR; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN TPS22965DSGR; LCSC C122837; not fitted
U2303: MFF2 eUICC; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm; MPN MFF2-EUICC-TBD; not fitted

Connections:
3V3_MAIN: U2302.1 (VIN), U2302.2 (VIN); also elsewhere on the board
5V_MAIN: U2302.4 (VBIAS); also elsewhere on the board
ESIM_CLK: R2313.2, U2303.6 (CLK)
ESIM_IO: R2314.2, U2303.3 (I/O)
ESIM_RST: R2312.2, U2303.7 (RST)
ESIM_VDD: C2305.1, R2311.2, U2303.8 (VCC)
FSPI_CLK: U2301.6 (CLK); also elsewhere on the board
FSPI_CS0_N: R2301.2, U2301.1 (~CS); also elsewhere on the board
FSPI_D0: U2301.5 (DI/IO_{0}); also elsewhere on the board
FSPI_D1: U2301.2 (DO/IO_{1}); also elsewhere on the board
FSPI_D3: R2303.2, U2301.7 (~HOLD/~RESET/IO_{3}); also elsewhere on the board
FSPI_WP_N: R2302.2, U2301.3 (~WP/IO_{2})
GND: C2301.2, C2302.2, C2303.2, C2304.2, C2305.2, D2301.3 (GND), D2301.8 (GND), D2302.3 (GND), D2302.8 (GND), J2301.6 (VSS), J2301.10 (DET_A), J2301.SH (SHIELD), R2310.2, U2301.4 (GND), U2301.9 (EP), U2302.5 (GND), U2302.9 (EP), U2303.1 (VSS); also elsewhere on the board
M2_PIN42: R2314.1; also elsewhere on the board
M2_PIN44: R2313.1; also elsewhere on the board
M2_PIN46: R2312.1; also elsewhere on the board
M2_PIN48: R2311.1; also elsewhere on the board
SDMMC0_DET: J2301.9 (DET_B); also elsewhere on the board
SD_CLK: D2301.1 (IO1), D2301.10 (FT1), J2301.5 (CLK), R2304.2
SD_CLK_SOC: R2304.1; also elsewhere on the board
SD_CMD: D2301.2 (IO2), D2301.9 (FT2), J2301.3 (CMD), R2305.2; also elsewhere on the board
SD_D0: D2301.4 (IO3), D2301.7 (FT3), J2301.7 (DAT0), R2306.2; also elsewhere on the board
SD_D1: D2301.5 (IO4), D2301.6 (FT4), J2301.8 (DAT1), R2307.2; also elsewhere on the board
SD_D2: D2302.1 (IO1), D2302.10 (FT1), J2301.1 (DAT2), R2308.2; also elsewhere on the board
SD_D3: D2302.2 (IO2), D2302.9 (FT2), J2301.2 (DAT3/CD), R2309.2; also elsewhere on the board
SD_PWR_EN: R2310.1, U2302.3 (ON); also elsewhere on the board
SD_SWITCH_CT: C2302.1, U2302.6 (CT)
SD_VDD: C2303.1, C2304.1, J2301.4 (VDD), U2302.7 (VOUT), U2302.8 (VOUT)
VCCIO_SD: R2305.1, R2306.1, R2307.1, R2308.1, R2309.1; also elsewhere on the board
VCC_1V8: C2301.1, R2301.1, R2302.1, R2303.1, U2301.8 (VCC); also elsewhere on the board

Notes on the sheet:
1.8 V SPI FLASH ON FSPI (VCCIO2 = VCC_1V8): NOR FITTED, SPI NAND DROP-IN
FSPI_D2 shares ball 1B16 with EMMC_RESET_N, so the flash runs x1/x2: WP# is pulled up, not wired. FSPI_D3 reaches HOLD#/IO3 for a later quad rework. Blank flash falls through to eMMC.
MICROSD (DNP): SDMMC0 ON VCCIO3 = VCCIO_SD, 3.3/1.8 V SWITCHED BY RK809
All DNP. Card detect closes DET_B to GND on insertion: SDMMC0_DET (R1202 pull-up) goes low = SD mode. SD_PWR_EN = GPIO0_A6 (PMUIO1, 3.3 V), pulled low: card power stays off until Linux enables it, which also lets UHS cards be power-cycled out of 1.8 V signalling.
MFF2 eSIM (DNP) ON M.2 SIM2 CONTACTS 42/44/46/48
SIM2 contacts per EM92xx PTS r1 and RM520N-GL HW guide 4.1.6: 40 detect, 42 data, 44 clk, 46 reset, 48 VDD. All DNP, so every profile keeps 42-48 open. Fitting needs the module SIM2 enable and an LPA (e.g. lpac).

Schematic: test-points.kicad_sch, Bring-up test pads

Parts:
TP2401: RK_RESET_N; TestPoint_Pad_D1.0mm
TP2402: PMIC_PWRON_N; TestPoint_Pad_D1.0mm
TP2403: PMIC_SLEEP; TestPoint_Pad_D1.0mm
TP2404: PMIC_INT_N; TestPoint_Pad_D1.0mm
TP2405: PMIC_CPU_EN; TestPoint_Pad_D1.0mm
TP2406: MCU_PWRON_KICK; TestPoint_Pad_D1.0mm
TP2407: MCU_PROCESSOR_RESET_ASSERT; TestPoint_Pad_D1.0mm
TP2408: MCU_PROCESSOR_RECOVERY_ASSERT; TestPoint_Pad_D1.0mm
TP2409: SARADC_BOOT_KEY; TestPoint_Pad_D1.0mm
TP2410: TSADC_SHUTDOWN; TestPoint_Pad_D1.0mm
TP2411: SOC_HEALTH; TestPoint_Pad_D1.0mm
TP2412: MCU_HEALTH_IN; TestPoint_Pad_D1.0mm
TP2413: EMMC_RESET_N; TestPoint_Pad_D1.0mm
TP2414: LPDDR4_RESETn; TestPoint_Pad_D1.0mm
TP2415: DDR_VDDQ_EN; TestPoint_Pad_D1.0mm
TP2416: OSC_ENABLE; TestPoint_Pad_D1.0mm
TP2417: MCU_MAIN5V_EN; TestPoint_Pad_D1.0mm
TP2418: MAIN5V_GOOD; TestPoint_Pad_D1.0mm
TP2419: MAIN3V3_EN; TestPoint_Pad_D1.0mm
TP2420: MAIN3V3_GOOD; TestPoint_Pad_D1.0mm
TP2421: MCU_ETH_POWER_EN; TestPoint_Pad_D1.0mm
TP2422: ETH_SWITCH_EN; TestPoint_Pad_D1.0mm
TP2423: ETH_3V3_GOOD; TestPoint_Pad_D1.0mm
TP2424: ETH_CORE_EN; TestPoint_Pad_D1.0mm
TP2425: ETH_PERST_N; TestPoint_Pad_D1.0mm
TP2426: ETH_CLOCK_OE_N; TestPoint_Pad_D1.0mm
TP2427: PCIE_PERST_SOC_N; TestPoint_Pad_D1.0mm
TP2428: PCIE_CLKREQ_N; TestPoint_Pad_D1.0mm
TP2429: PCIE_WAKE_N; TestPoint_Pad_D1.0mm
TP2430: MCU_MODEM_POWER_EN; TestPoint_Pad_D1.0mm
TP2431: MODEM_BUCK_EN; TestPoint_Pad_D1.0mm
TP2432: MODEM_BUCK_GOOD; TestPoint_Pad_D1.0mm
TP2433: MODEM_FUSE_EN; TestPoint_Pad_D1.0mm
TP2434: MODEM_SWITCH_GOOD; TestPoint_Pad_D1.0mm
TP2435: MODEM_RAIL_GOOD; TestPoint_Pad_D1.0mm
TP2436: MODEM_RESET_N; TestPoint_Pad_D1.0mm
TP2437: MODEM_OFF_N; TestPoint_Pad_D1.0mm
TP2438: MODEM_USB_OE_N; TestPoint_Pad_D1.0mm
TP2439: MODEM_USB_VALID; TestPoint_Pad_D1.0mm
TP2440: POE_TPH_N; TestPoint_Pad_D1.0mm
TP2441: POE_TPL_N; TestPoint_Pad_D1.0mm
TP2442: POE_BT_N; TestPoint_Pad_D1.0mm
TP2443: SD_PWR_EN; TestPoint_Pad_D1.0mm
TP2444: MON_ALERT_N; TestPoint_Pad_D1.0mm
TP2445: ISO_12V_PSU; TestPoint_Pad_D1.0mm
TP2446: AUX_12V_IN; TestPoint_Pad_D1.0mm
TP2447: ISO_12V_BUS; TestPoint_Pad_D1.0mm
TP2448: ISO_12V; TestPoint_Pad_D1.0mm
TP2449: 5V_MAIN; TestPoint_Pad_D1.0mm
TP2450: 3V3_MAIN; TestPoint_Pad_D1.0mm
TP2451: +3V3; TestPoint_Pad_D1.0mm
TP2452: VCC3V3_PMU; TestPoint_Pad_D1.0mm
TP2453: VCC_1V8; TestPoint_Pad_D1.0mm
TP2454: VCCA_1V8; TestPoint_Pad_D1.0mm
TP2455: VCCA1V8_PMU; TestPoint_Pad_D1.0mm
TP2456: VDDA_0V9; TestPoint_Pad_D1.0mm
TP2457: VDDA0V9_PMU; TestPoint_Pad_D1.0mm
TP2458: VDD_CPU; TestPoint_Pad_D1.0mm
TP2459: VDD_LOGIC; TestPoint_Pad_D1.0mm
TP2460: VDD_GPU; TestPoint_Pad_D1.0mm
TP2461: VDD_NPU; TestPoint_Pad_D1.0mm
TP2462: VDD_DDR_1V1; TestPoint_Pad_D1.0mm
TP2463: VDD_DDR_0V6; TestPoint_Pad_D1.0mm
TP2464: VCCIO_SD; TestPoint_Pad_D1.0mm
TP2465: MODEM_3V7_RAW; TestPoint_Pad_D1.0mm
TP2466: MODEM_VCC; TestPoint_Pad_D1.0mm
TP2467: ETH_3V3; TestPoint_Pad_D1.0mm
TP2468: ETH_0V95; TestPoint_Pad_D1.0mm
TP2469: USB_AVDD_0V9; TestPoint_Pad_D1.0mm
TP2470: MULTI_AVDD_0V9; TestPoint_Pad_D1.0mm
TP2471: GND; TestPoint_Pad_D1.0mm
TP2473: GND CLIP; TestPoint_Keystone_5005-5009_Compact; MPN 5006

Connections:
3V3_MAIN: TP2450.1 (1_1); also elsewhere on the board
5V_MAIN: TP2449.1 (1_1); also elsewhere on the board
+3V3: TP2451.1 (1_1); also elsewhere on the board
AUX_12V_IN: TP2446.1 (1_1); also elsewhere on the board
DDR_VDDQ_EN: TP2415.1 (1_1); also elsewhere on the board
EMMC_RESET_N: TP2413.1 (1_1); also elsewhere on the board
ETH_0V95: TP2468.1 (1_1); also elsewhere on the board
ETH_3V3: TP2467.1 (1_1); also elsewhere on the board
ETH_3V3_GOOD: TP2423.1 (1_1); also elsewhere on the board
ETH_CLOCK_OE_N: TP2426.1 (1_1); also elsewhere on the board
ETH_CORE_EN: TP2424.1 (1_1); also elsewhere on the board
ETH_PERST_N: TP2425.1 (1_1); also elsewhere on the board
ETH_SWITCH_EN: TP2422.1 (1_1); also elsewhere on the board
GND: TP2471.1 (1_1), TP2473.1 (1_1); also elsewhere on the board
ISO_12V: TP2448.1 (1_1); also elsewhere on the board
ISO_12V_BUS: TP2447.1 (1_1); also elsewhere on the board
ISO_12V_PSU: TP2445.1 (1_1); also elsewhere on the board
LPDDR4_RESETn: TP2414.1 (1_1); also elsewhere on the board
MAIN3V3_EN: TP2419.1 (1_1); also elsewhere on the board
MAIN3V3_GOOD: TP2420.1 (1_1); also elsewhere on the board
MAIN5V_GOOD: TP2418.1 (1_1); also elsewhere on the board
MCU_ETH_POWER_EN: TP2421.1 (1_1); also elsewhere on the board
MCU_HEALTH_IN: TP2412.1 (1_1); also elsewhere on the board
MCU_MAIN5V_EN: TP2417.1 (1_1); also elsewhere on the board
MCU_MODEM_POWER_EN: TP2430.1 (1_1); also elsewhere on the board
MCU_PROCESSOR_RECOVERY_ASSERT: TP2408.1 (1_1); also elsewhere on the board
MCU_PROCESSOR_RESET_ASSERT: TP2407.1 (1_1); also elsewhere on the board
MCU_PWRON_KICK: TP2406.1 (1_1); also elsewhere on the board
MODEM_3V7_RAW: TP2465.1 (1_1); also elsewhere on the board
MODEM_BUCK_EN: TP2431.1 (1_1); also elsewhere on the board
MODEM_BUCK_GOOD: TP2432.1 (1_1); also elsewhere on the board
MODEM_FUSE_EN: TP2433.1 (1_1); also elsewhere on the board
MODEM_OFF_N: TP2437.1 (1_1); also elsewhere on the board
MODEM_RAIL_GOOD: TP2435.1 (1_1); also elsewhere on the board
MODEM_RESET_N: TP2436.1 (1_1); also elsewhere on the board
MODEM_SWITCH_GOOD: TP2434.1 (1_1); also elsewhere on the board
MODEM_USB_OE_N: TP2438.1 (1_1); also elsewhere on the board
MODEM_USB_VALID: TP2439.1 (1_1); also elsewhere on the board
MODEM_VCC: TP2466.1 (1_1); also elsewhere on the board
MON_ALERT_N: TP2444.1 (1_1); also elsewhere on the board
MULTI_AVDD_0V9: TP2470.1 (1_1); also elsewhere on the board
OSC_ENABLE: TP2416.1 (1_1); also elsewhere on the board
PCIE_CLKREQ_N: TP2428.1 (1_1); also elsewhere on the board
PCIE_PERST_SOC_N: TP2427.1 (1_1); also elsewhere on the board
PCIE_WAKE_N: TP2429.1 (1_1); also elsewhere on the board
PMIC_CPU_EN: TP2405.1 (1_1); also elsewhere on the board
PMIC_INT_N: TP2404.1 (1_1); also elsewhere on the board
PMIC_PWRON_N: TP2402.1 (1_1); also elsewhere on the board
PMIC_SLEEP: TP2403.1 (1_1); also elsewhere on the board
POE_BT_N: TP2442.1 (1_1); also elsewhere on the board
POE_TPH_N: TP2440.1 (1_1); also elsewhere on the board
POE_TPL_N: TP2441.1 (1_1); also elsewhere on the board
RK_RESET_N: TP2401.1 (1_1); also elsewhere on the board
SARADC_BOOT_KEY: TP2409.1 (1_1); also elsewhere on the board
SD_PWR_EN: TP2443.1 (1_1); also elsewhere on the board
SOC_HEALTH: TP2411.1 (1_1); also elsewhere on the board
TSADC_SHUTDOWN: TP2410.1 (1_1); also elsewhere on the board
USB_AVDD_0V9: TP2469.1 (1_1); also elsewhere on the board
VCC3V3_PMU: TP2452.1 (1_1); also elsewhere on the board
VCCA1V8_PMU: TP2455.1 (1_1); also elsewhere on the board
VCCA_1V8: TP2454.1 (1_1); also elsewhere on the board
VCCIO_SD: TP2464.1 (1_1); also elsewhere on the board
VCC_1V8: TP2453.1 (1_1); also elsewhere on the board
VDDA0V9_PMU: TP2457.1 (1_1); also elsewhere on the board
VDDA_0V9: TP2456.1 (1_1); also elsewhere on the board
VDD_CPU: TP2458.1 (1_1); also elsewhere on the board
VDD_DDR_0V6: TP2463.1 (1_1); also elsewhere on the board
VDD_DDR_1V1: TP2462.1 (1_1); also elsewhere on the board
VDD_GPU: TP2460.1 (1_1); also elsewhere on the board
VDD_LOGIC: TP2459.1 (1_1); also elsewhere on the board
VDD_NPU: TP2461.1 (1_1); also elsewhere on the board

Notes on the sheet:
RESETS, ENABLES AND POWER-GOODS
RAILS
GROUND
Bare pads: no BOM line. Local nets without a global label stay on headers: MCU_NRST_N and SWD on J201, POWER_FAULT_N / SERVICE UART / modem reset lines on J102.
